File: pt_amps.kicad_sch (KiCad schematic)
At the start: 39 parts, among them J21 Screw_Terminal_01x02, J22 Screw_Terminal_01x02, J23 Screw_Terminal_01x02, J24 Screw_Terminal_01x02, J25 Conn_01x04_Female, U11 LM324DT

Commit message: add overvoltage diodes
Parts:
- added D10, D11, D12, D16: SS54, karca_custom_footprints:DO-214AC, symbol Device:D_Schottky
Connections:
- net PT1_CAL: now also D11.2 (A)
- net PT2_CAL: now also D16.2 (A)
- net PT3_CAL: now also D10.2 (A)
- net PT4_CAL: now also D12.2 (A)
- new net +5V: D10.1 (K), D11.1 (K), D12.1 (K), D16.1 (K)
Changed lines of the file:
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@@
   (junction (at 95.25 52.07) (diameter 0) (color 0 0 0 0)
   )
+  (junction (at 215.9 50.8) (diameter 0) (color 0 0 0 0)
+  )
   (junction (at 34.29 109.22) (diameter 0) (color 0 0 0 0)
   )
@@
   (junction (at 210.82 62.23) (diameter 0) (color 0 0 0 0)
   )
+  (junction (at 101.6 52.07) (diameter 0) (color 0 0 0 0)
+  )
   (junction (at 149.86 48.26) (diameter 0) (color 0 0 0 0)
   )
@@
   (junction (at 209.55 113.03) (diameter 0) (color 0 0 0 0)
   )
+  (junction (at 214.63 113.03) (diameter 0) (color 0 0 0 0)
+  )
   (junction (at 62.23 109.22) (diameter 0) (color 0 0 0 0)
   )
+  (junction (at 100.33 111.76) (diameter 0) (color 0 0 0 0)
+  )
   (junction (at 163.83 48.26) (diameter 0) (color 0 0 0 0)
   )
@@
   (junction (at 210.82 50.8) (diameter 0) (color 0 0 0 0)
   )
-  (wire (pts (xy 210.82 50.8) (xy 212.09 50.8))
+  (wire (pts (xy 210.82 50.8) (xy 215.9 50.8))
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
@@
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
+  (wire (pts (xy 100.33 111.76) (xy 102.235 111.76))
+    (stroke (width 0) (type default) (color 0 0 0 0))
+  )
   (wire (pts (xy 34.29 53.34) (xy 34.29 49.53))
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
+  (wire (pts (xy 101.6 52.07) (xy 103.505 52.07))
+    (stroke (width 0) (type default) (color 0 0 0 0))
+  )
   (wire (pts (xy 148.59 104.14) (xy 148.59 107.95))
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
+  (wire (pts (xy 215.9 50.8) (xy 217.805 50.8))
+    (stroke (width 0) (type default) (color 0 0 0 0))
+  )
   (wire (pts (xy 48.26 39.37) (xy 60.96 39.37))
     (stroke (width 0) (type default) (color 0 0 0 0))
@@
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
-  (wire (pts (xy 95.25 111.76) (xy 96.52 111.76))
+  (wire (pts (xy 95.25 111.76) (xy 100.33 111.76))
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
@@
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
-  (wire (pts (xy 209.55 113.03) (xy 210.82 113.03))
+  (wire (pts (xy 209.55 113.03) (xy 214.63 113.03))
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
@@
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
-  (wire (pts (xy 95.25 52.07) (xy 96.52 52.07))
+  (wire (pts (xy 95.25 52.07) (xy 101.6 52.07))
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
@@
   )
   (wire (pts (xy 176.53 110.49) (xy 176.53 115.57))
+    (stroke (width 0) (type default) (color 0 0 0 0))
+  )
+  (wire (pts (xy 214.63 113.03) (xy 216.535 113.03))
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
@@
     (effects (font (size 1.27 1.27)) (justify left bottom))
   )
-  (global_label "PT2_CAL" (shape output) (at 212.09 50.8 0) (fields_autoplaced)
+  (global_label "PT2_CAL" (shape output) (at 217.805 50.8 0) (fields_autoplaced)
     (effects (font (size 1.27 1.27)) (justify left))
-    (property "Intersheet References" "${INTERSHEET_REFS}" (id 0) (at 222.3045 50.7206 0)
+    (property "Intersheet References" "${INTERSHEET_REFS}" (id 0) (at 228.0195 50.7206 0)
       (effects (font (size 1.27 1.27)) (justify left) hide)
     )
   )
-  (global_label "PT1_CAL" (shape output) (at 96.52 52.07 0) (fields_autoplaced)
+  (global_label "PT1_CAL" (shape output) (at 103.505 52.07 0) (fields_autoplaced)
     (effects (font (size 1.27 1.27)) (justify left))
-    (property "Intersheet References" "${INTERSHEET_REFS}" (id 0) (at 106.7345 51.9906 0)
+    (property "Intersheet References" "${INTERSHEET_REFS}" (id 0) (at 113.7195 51.9906 0)
       (effects (font (size 1.27 1.27)) (justify left) hide)
     )
   )
-  (global_label "PT3_CAL" (shape output) (at 96.52 111.76 0) (fields_autoplaced)
+  (global_label "PT3_CAL" (shape output) (at 102.235 111.76 0) (fields_autoplaced)
     (effects (font (size 1.27 1.27)) (justify left))
-    (property "Intersheet References" "${INTERSHEET_REFS}" (id 0) (at 106.7345 111.6806 0)
+    (property "Intersheet References" "${INTERSHEET_REFS}" (id 0) (at 112.4495 111.6806 0)
       (effects (font (size 1.27 1.27)) (justify left) hide)
     )
   )
-  (global_label "PT4_CAL" (shape output) (at 210.82 113.03 0) (fields_autoplaced)
+  (global_label "PT4_CAL" (shape output) (at 216.535 113.03 0) (fields_autoplaced)
     (effects (font (size 1.27 1.27)) (justify left))
-    (property "Intersheet References" "${INTERSHEET_REFS}" (id 0) (at 221.0345 112.9506 0)
+    (property "Intersheet References" "${INTERSHEET_REFS}" (id 0) (at 226.7495 112.9506 0)
       (effects (font (size 1.27 1.27)) (justify left) hide)
     )
@@
     (pin "1")
   )
+  (symbol (lib_id "power:+5V") (at 101.6 44.45 0) (unit 1)
+    (in_bom yes) (on_board yes) (fields_autoplaced)
+    (property "Reference" "#PWR0161" (id 0) (at 101.6 48.26 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Value" "+5V" (id 1) (at 101.6 39.37 0))
+    (property "Footprint" "" (id 2) (at 101.6 44.45 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "" (id 3) (at 101.6 44.45 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "1")
+  )
+  (symbol (lib_id "Device:D_Schottky") (at 101.6 48.26 270) (unit 1)
+    (in_bom yes) (on_board yes) (fields_autoplaced)
+    (property "Reference" "D11" (id 0) (at 104.14 46.6724 90)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Value" "SS54" (id 1) (at 104.14 49.2124 90)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Footprint" "karca_custom_footprints:DO-214AC" (id 2) (at 101.6 48.26 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "~" (id 3) (at 101.6 48.26 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "1")
+    (pin "2")
+  )
   (symbol (lib_id "Device:R_US") (at 95.25 116.84 0) (unit 1)
     (in_bom yes) (on_board yes) (fields_autoplaced)
@@
     (pin "2")
   )
+  (symbol (lib_id "power:+5V") (at 100.33 104.14 0) (unit 1)
+    (in_bom yes) (on_board yes) (fields_autoplaced)
+    (property "Reference" "#PWR0159" (id 0) (at 100.33 107.95 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Value" "+5V" (id 1) (at 100.33 99.06 0))
+    (property "Footprint" "" (id 2) (at 100.33 104.14 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "" (id 3) (at 100.33 104.14 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "1")
+  )
+  (symbol (lib_id "Device:D_Schottky") (at 215.9 46.99 270) (unit 1)
+    (in_bom yes) (on_board yes) (fields_autoplaced)
+    (property "Reference" "D16" (id 0) (at 218.44 45.4024 90)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Value" "SS54" (id 1) (at 218.44 47.9424 90)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Footprint" "karca_custom_footprints:DO-214AC" (id 2) (at 215.9 46.99 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "~" (id 3) (at 215.9 46.99 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "1")
+    (pin "2")
+  )
+  (symbol (lib_id "power:+5V") (at 214.63 105.41 0) (unit 1)
+    (in_bom yes) (on_board yes) (fields_autoplaced)
+    (property "Reference" "#PWR0160" (id 0) (at 214.63 109.22 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Value" "+5V" (id 1) (at 214.63 100.33 0))
+    (property "Footprint" "" (id 2) (at 214.63 105.41 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "" (id 3) (at 214.63 105.41 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "1")
+  )
   (symbol (lib_id "power:GND") (at 95.25 72.39 0) (unit 1)
     (in_bom yes) (on_board yes) (fields_autoplaced)
@@
     (pin "2")
   )
+  (symbol (lib_id "power:+5V") (at 215.9 43.18 0) (unit 1)
+    (in_bom yes) (on_board yes) (fields_autoplaced)
+    (property "Reference" "#PWR0158" (id 0) (at 215.9 46.99 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Value" "+5V" (id 1) (at 215.9 38.1 0))
+    (property "Footprint" "" (id 2) (at 215.9 43.18 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "" (id 3) (at 215.9 43.18 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "1")
+  )
   (symbol (lib_id "power:GND") (at 34.29 120.65 0) (unit 1)
     (in_bom yes) (on_board yes) (fields_autoplaced)
@@
     )
     (pin "1")
+  )
+  (symbol (lib_id "Device:D_Schottky") (at 214.63 109.22 270) (unit 1)
+    (in_bom yes) (on_board yes) (fields_autoplaced)
+    (property "Reference" "D12" (id 0) (at 217.17 107.6324 90)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Value" "SS54" (id 1) (at 217.17 110.1724 90)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Footprint" "karca_custom_footprints:DO-214AC" (id 2) (at 214.63 109.22 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "~" (id 3) (at 214.63 109.22 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "1")
+    (pin "2")
   )
   (symbol (lib_id "Amplifier_Operational:LM324") (at 194.31 113.03 0) (unit 4)
@@
       (effects (font (size 1.27 1.27)) hide)
     )
+    (pin "1")
+    (pin "2")
+  )
+  (symbol (lib_id "Device:D_Schottky") (at 100.33 107.95 270) (unit 1)
+    (in_bom yes) (on_board yes) (fields_autoplaced)
+    (property "Reference" "D10" (id 0) (at 102.87 106.3624 90)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Value" "SS54" (id 1) (at 102.87 108.9024 90)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Footprint" "karca_custom_footprints:DO-214AC" (id 2) (at 100.33 107.95 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "~" (id 3) (at 100.33 107.95 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
