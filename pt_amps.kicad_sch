File: pt_amps.kicad_sch (KiCad schematic)
At the start: 47 parts

Commit message: first revision of full schematic copied over
Parts:
- removed C? (x8): 1nF, symbol Device:C_Polarized
- removed C?: 100nF, symbol Device:C_Polarized
- added C? (x8): 1nF, symbol Device:C
- added C?: 100nF, symbol Device:C
Connections:
- net +10V: now also C?.1
- net GND: now also C?.2, C?.2, C?.2, C?.2, C?.2
- net PT1_CAL: now also C?.2
- net PT2_CAL: now also C?.2
- net PT3_CAL: now also C?.2
- net PT4_CAL: now also C?.2
- net at R?.1, R?.2: now also C?.1 (x4)
- net at R?.1, U?.3 (+): now also C?.1
- net at R?.1, U?.10 (+): now also C?.1
- net at R?.1, U?.12 (+): now also C?.1
- net at R?.1, U?.5 (+): now also C?.1
Other:
- company: (none) -> Rice Eclipse
- title: (none) -> Pressure Transducer Amplification

Commit message: added schematic pdf for review
Parts:
- gave numbers to parts that had none: 43

Commit message: added footprints and started schematic review revisions
Parts:
- removed J20, J21, J22, J23, J25, J26, J27, J28: Conn_01x01_Male, symbol Connector:Conn_01x01_Male
- added J20, J21, J22, J23: Conn_01x02_Female, symbol Connector:Conn_01x02_Female
- C18, C19, C20, C21, C22, C23, C24, C25, C26: footprint (none) -> Capacitor_SMD:C_1206_3216Metric
- F11, F12, F13, F14: value Fuse -> 3588-20; footprint (none) -> karca_custom_footprints:3588-20 fuse
- R54, R55, R56, R57, R58, R59, R60, R61, R62, R63, R64, R65, R66, R67, R68, R69, R70, R71, R72, R73: footprint (none) -> Resistor_SMD:R_1206_3216Metric
- U8: value LM324 -> LM324DT; footprint (none) -> Package_SO:SOIC-14_3.9x8.7mm_P1.27mm
Connections:
- net PT1-: now also J20.2 (Pin_2)
- net PT2-: now also J23.2 (Pin_2)
- net PT3-: now also J21.2 (Pin_2)
- net PT4-: now also J22.2 (Pin_2)
- net at F11.2: now also J20.1 (Pin_1)
- net at F13.2: now also J22.1 (Pin_1)
- net at F12.2: now also J21.1 (Pin_1)
- net at F14.2: now also J23.1 (Pin_1)

Commit message: schematic editing + creating some footprints
Parts:
- removed J24: Conn_01x04, symbol Connector_Generic:Conn_01x04
- added J19: Conn_01x04_Female, Connector_PinHeader_2.54mm:PinHeader_1x04_P2.54mm_Vertical, symbol Connector:Conn_01x04_Female
- J20, J21, J22, J23: footprint (none) -> Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical
Connections:
- net PT1-: now also J19.1 (Pin_1)
- net PT2-: now also J19.2 (Pin_2)
- net PT3-: now also J19.3 (Pin_3)
- net PT4-: now also J19.4 (Pin_4)
Changed lines of the file:
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@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Footprint" "" (id 2) (at 29.21 46.99 0)
+    (property "Footprint" "Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical" (id 2) (at 29.21 46.99 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
     (pin "2")
   )
+  (symbol (lib_id "Connector:Conn_01x04_Female") (at 127 163.83 0) (unit 1)
+    (in_bom yes) (on_board yes) (fields_autoplaced)
+    (property "Reference" "J19" (id 0) (at 128.27 163.8299 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Value" "Conn_01x04_Female" (id 1) (at 128.27 166.3699 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Footprint" "Connector_PinHeader_2.54mm:PinHeader_1x04_P2.54mm_Vertical" (id 2) (at 127 163.83 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "~" (id 3) (at 127 163.83 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "1")
+    (pin "2")
+    (pin "3")
+    (pin "4")
+  )
   (symbol (lib_id "Device:R_US") (at 43.18 49.53 270) (unit 1)
     (in_bom yes) (on_board yes) (fields_autoplaced)
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Footprint" "" (id 2) (at 29.21 106.68 0)
+    (property "Footprint" "Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical" (id 2) (at 29.21 106.68 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Footprint" "" (id 2) (at 143.51 107.95 0)
+    (property "Footprint" "Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical" (id 2) (at 143.51 107.95 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Footprint" "" (id 2) (at 144.78 45.72 0)
+    (property "Footprint" "Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical" (id 2) (at 144.78 45.72 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
     (pin "2")
   )
-  (symbol (lib_id "Connector_Generic:Conn_01x04") (at 127 163.83 0) (unit 1)
-    (in_bom yes) (on_board yes) (fields_autoplaced)
-    (property "Reference" "J24" (id 0) (at 129.54 163.8299 0)
-      (effects (font (size 1.27 1.27)) (justify left))
-    )
-    (property "Value" "Conn_01x04" (id 1) (at 129.54 166.3699 0)
-      (effects (font (size 1.27 1.27)) (justify left))
-    )
-    (property "Footprint" "" (id 2) (at 127 163.83 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Datasheet" "~" (id 3) (at 127 163.83 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (pin "1")
-    (pin "2")
-    (pin "3")
-    (pin "4")
-  )
   (symbol (lib_id "Device:R_US") (at 209.55 129.54 0) (unit 1)

Commit message: preliminary layout and started pwr plane config
Parts:
- removed J20, J21, J22, J23: Conn_01x02_Female, Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical, symbol Connector:Conn_01x02_Female
- added J21, J22, J23, J24: Screw_Terminal_01x02, 1190363:1190363, symbol Connector:Screw_Terminal_01x02
- F13: renamed from F14; footprint karca_custom_footprints:3588-20 fuse -> 3588-20:358820
- F14: renamed from F11; footprint karca_custom_footprints:3588-20 fuse -> 3588-20:358820
- F15: renamed from F12; footprint karca_custom_footprints:3588-20 fuse -> 3588-20:358820
- F16: renamed from F13; footprint karca_custom_footprints:3588-20 fuse -> 3588-20:358820
- renumbered C26 to C25, C20 to C26, C24 to C27, C18 to C28, C21 to C29, C25 to C30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
Connections:
- net PT1-: now also J22.2 (Pin_2)
- net PT2-: now also J21.2 (Pin_2)
- net PT3-: now also J23.2 (Pin_2)
- net PT4-: now also J24.2 (Pin_2)
- net at F14.2: now also J22.1 (Pin_1)
- net at F15.2: now also J23.1 (Pin_1)
- net at F16.2: now also J24.1 (Pin_1)
- net at F13.2: now also J21.1 (Pin_1)
