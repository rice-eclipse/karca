# Repository rice-eclipse/karca

File README.md:

# kARCA: An engine controller PCB for Rice Eclipse

kARCA is Rice Eclipse's next generation of engine controller boards.
Its intended use is for data collection and valve actuation control on the Titan and Proxima rocket
motors.

It was designed in 2022 by Rice Eclipse.

## Usage

This board was designed in [KiCAD](https://www.kicad.org/).
Exports (such as gerber files) should be stored in the `target` directory (covered by gitignore).

It connects to a Raspberry Pi running our custom controller software,
[`slonk`](https://github.com/rice-eclipse/slonk), which in turn interfaces with the user dashboard
[`slonkboard`](https://github.com/rice-eclipse/slonkboard).

## Further documentation

A full overview of the design of kARCA is available in [docs/karca.md](docs/karca.md).

## License

This design is licensed under the Creative Commons Attribution-ShareAlike 4.0 International license
(CC BY-SA 4.0).

For more information, refer to [LICENSE.md](LICENSE.md).

## KiCad design karca.kicad_pcb

Parts:
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3

Notes on the sheet:
Control system and data collection for inert flow and static hot fires of experimental hybrid engines. Compatible Engines: - Luna - Proxima - Titan II ARCA 2.0 is a re-spin of ARCA, which is a design upgrade on "Mk 1.1" Avionics Lead: Spencer Darwall Subteam Lead: Amy Danjul Avionics Engineers: Cla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
ARCA 2.0

Parts:
HBT1: BLU; LED_1206_3216Metric
J33: 2540-5; PinSocket_2x20_P2.54mm_Horizontal
R89: 150; R_1206_3216Metric

Connections:
+5V: J33.2, J33.4; also elsewhere on the board
/Drivers/DRV_CTL_1: J33.35; also elsewhere on the board
/Drivers/DRV_CTL_2: J33.33; also elsewhere on the board
/Drivers/DRV_CTL_3: J33.31; also elsewhere on the board
/Drivers/DRV_CTL_4: J33.15; also elsewhere on the board
/Drivers/DRV_CTL_5: J33.13; also elsewhere on the board
/Drivers/DRV_CTL_6: J33.11; also elsewhere on the board
/Load Cells/CS: J33.22; also elsewhere on the board
/Load Cells/SPI_CLK: J33.23; also elsewhere on the board
/Load Cells/SPI_MISO: J33.21; also elsewhere on the board
/Load Cells/SPI_MOSI: J33.19; also elsewhere on the board
/PT Amplification/CS: J33.24; also elsewhere on the board
/Raspberry Pi/ADC3_CS: J33.26; also elsewhere on the board
GND: HBT1.1 (K), J33.6, J33.9, J33.14, J33.20, J33.25, J33.30, J33.34, J33.39; also elsewhere on the board
unnamed: HBT1.2 (A), R89.1
unnamed: J33.29, R89.2

Parts:
C1, C2, C3, C4: 10u; C_1206_3216Metric
CON_BAT1: Screw_Terminal_01x02; 1190363
CON_FAN1: Screw_Terminal_01x02; 1190363
CON_ROUTER1: Screw_Terminal_01x02; 1190363
D1: 1N5822RLG; D_DO-201AD_P15.24mm_Horizontal
D3, D5: CDBA340-HF; D_SMA
LED13, LED14, LED15: RED; LED_1206_3216Metric
R1: 510; R_1206_3216Metric
R2: 68k; R_1206_3216Metric
R3: 390; R_1206_3216Metric
R4: 10k; R_1206_3216Metric
R5: 150; R_1206_3216Metric
SW1, SW2: S101031MS02Q
TP1, TP2, TP3, TP4, TP5: TestPoint; TestPoint_Pad_D2.0mm
U1: LM1084-ADJ; TO-263-3_TabPin2
U2: LM1084-5.0; TO-263-3_TabPin2

Connections:
+5V: C4.1, D5.2 (A), LED15.2 (A), TP5.1, U2.2 (VO); also elsewhere on the board
+10V: C2.1, D3.2 (A), LED14.2 (A), R2.1, TP4.1, U1.2 (VO); also elsewhere on the board
+12V: C1.1, C3.1, CON_ROUTER1.1, D1.1 (K), D3.1 (K), D5.1 (K), LED13.2 (A), SW2.1 (A), TP3.1, U1.3 (VI), U2.3 (VI); also elsewhere on the board
/regulators/10V_FB: R2.2, R4.1, U1.1 (ADJ)
/regulators/12V_CON: CON_BAT1.1, SW1.1 (A), TP1.1
/regulators/12V_PRERECT: D1.2 (A), SW1.2 (B), TP2.1
/regulators/FAN_POW: CON_FAN1.1, SW2.2 (B)
GND: C1.2, C2.2, C3.2, C4.2, CON_BAT1.2, CON_FAN1.2, CON_ROUTER1.2, R1.2, R3.2, R4.2, R5.2, U2.1 (GND); also elsewhere on the board
unnamed: LED13.1 (K), R1.1
unnamed: LED14.1 (K), R3.1
unnamed: LED15.1 (K), R5.1

Notes on the sheet:
Vo = 1.25V * (1+R1/R2)
BATTERY
FAN
ROUTER

Parts:
ADC3: MCP3208-CI/SL; SOIC-16_3.9x9.9mm_P1.27mm
C20: 100n; C_1206_3216Metric
D42, D43, D44, D45, D46, D47, D48, D49: CDBA340-HF; D_SMA
J8: Conn_01x08_Female; PinSocket_1x08_P2.54mm_Vertical
J9: Screw_Terminal_01x12

Connections:
+5V: ADC3.15 (Vref), ADC3.16 (Vdd), C20.2, J9.1, J9.4, J9.7, J9.10; also elsewhere on the board
+10V: D42.1 (K), D44.1 (K), D46.1 (K), D48.1 (K); also elsewhere on the board
/Load Cells/SPI_CLK: ADC3.13 (CLK); also elsewhere on the board
/Load Cells/SPI_MISO: ADC3.12 (Dout); also elsewhere on the board
/Load Cells/SPI_MOSI: ADC3.11 (Din); also elsewhere on the board
/Raspberry Pi/ADC3_CS: ADC3.10 (~CS/SHDN); also elsewhere on the board
/Thermocouples/TC1: ADC3.1 (CH0), D42.2 (A), D43.1 (K), J8.1, J9.2
/Thermocouples/TC2: ADC3.2 (CH1), D44.2 (A), D45.1 (K), J8.2, J9.5
/Thermocouples/TC3: ADC3.3 (CH2), D46.2 (A), D47.1 (K), J8.3, J9.8
/Thermocouples/TC4: ADC3.4 (CH3), D48.2 (A), D49.1 (K), J8.4, J9.11
GND: ADC3.9 (DGND), ADC3.14 (AGND), C20.1, D43.2 (A), D45.2 (A), D47.2 (A), D49.2 (A), J9.3, J9.6, J9.9, J9.12; also elsewhere on the board
unnamed: ADC3.5 (CH4), J8.5
unnamed: ADC3.6 (CH5), J8.6
unnamed: ADC3.7 (CH6), J8.7
unnamed: ADC3.8 (CH7), J8.8

Parts:
ADC1: MCP3208-CI/SL; SOIC-16_3.9x9.9mm_P1.27mm
C5, C6, C7, C10: 1u; C_1206_3216Metric
C8, C9, C11, C12, C14, C15, C16, C17: 1n; C_1206_3216Metric
C13, C18: 100n; C_1206_3216Metric
D9, D14, D15, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33: CDBA340-HF; D_SMA
J3, J4: Screw_Terminal_01x08; 1190370
J5: Conn_01x08_Female; PinSocket_1x08_P2.54mm_Vertical
R30, R31, R32, R36: 20K; R_1206_3216Metric
R33, R34, R35, R39: 200; R_1206_3216Metric
R37, R38, R40, R41, R42, R43, R44, R45: 68k; R_1206_3216Metric
R46, R48, R50, R52: 15k; R_1206_3216Metric
R47, R49, R51, R53: 10k; R_1206_3216Metric
RV1, RV2, RV3, RV4: 30k; Potentiometer_Bourns_3296W_Vertical
TP12, TP13, TP14, TP15, TP16, TP17, TP18, TP19, TP20, TP21, TP22, TP23: TestPoint; TestPoint_Pad_D2.0mm
U3, U4, U5, U6: MCP6N11; SOIC-8_3.9x4.9mm_P1.27mm
U7: LM324DT; SOIC-14_3.9x8.7mm_P1.27mm

Connections:
+5V: ADC1.15 (Vref), ADC1.16 (Vdd), C5.1, C6.1, C7.1, C10.1, C18.2, D9.1 (K), D15.1 (K), D18.1 (K), D20.1 (K), D22.1 (K), D24.1 (K), D26.1 (K), D28.1 (K), D30.1 (K), D31.1 (K), D32.1 (K), D33.1 (K), J3.1, J3.5, J4.1, J4.5, RV1.1, RV2.1, RV3.1, RV4.1, U3.7 (Vdd), U3.8 (EN/nCAL), U4.7 (Vdd), U4.8 (EN/nCAL), U5.7 (Vdd), U5.8 (EN/nCAL), U6.7 (Vdd), U6.8 (EN/nCAL); also elsewhere on the board
+10V: C13.1, U7.4 (V+); also elsewhere on the board
/Load Cells/CS: ADC1.10 (~CS/SHDN); also elsewhere on the board
/Load Cells/LC1+: D22.2 (A), D23.1 (K), J3.3, TP13.1, U3.3 (Vip)
/Load Cells/LC1-: D9.2 (A), D14.1 (K), J3.2, TP12.1, U3.2 (Vim)
/Load Cells/LC1_CAL: ADC1.1 (CH0), C14.2, D30.2 (A), J5.1, R46.1, U7.1
/Load Cells/LC1_PREC: R30.1, R33.2, R37.1, TP20.1, U3.6 (Vout)
/Load Cells/LC2+: D24.2 (A), D25.1 (K), J3.7, TP15.1, U4.3 (Vip)
/Load Cells/LC2-: D15.2 (A), D17.1 (K), J3.6, TP14.1, U4.2 (Vim)
/Load Cells/LC2_CAL: ADC1.2 (CH1), C15.2, D31.2 (A), J5.2, R48.1, U7.7
/Load Cells/LC2_PREC: R31.1, R34.2, R38.1, TP21.1, U4.6 (Vout)
/Load Cells/LC3+: D26.2 (A), D27.1 (K), J4.3, TP17.1, U5.3 (Vip)
/Load Cells/LC3-: D18.2 (A), D19.1 (K), J4.2, TP16.1, U5.2 (Vim)
/Load Cells/LC3_CAL: ADC1.3 (CH2), C16.2, D32.2 (A), J5.3, R50.1, U7.8
/Load Cells/LC3_PREC: R32.1, R35.2, R40.1, TP22.1, U5.6 (Vout)
/Load Cells/LC4+: D28.2 (A), D29.1 (K), J4.7, TP19.1, U6.3 (Vip)
/Load Cells/LC4-: D20.2 (A), D21.1 (K), J4.6, TP18.1, U6.2 (Vim)
/Load Cells/LC4_CAL: ADC1.4 (CH3), C17.2, D33.2 (A), J5.4, R52.1, U7.14
/Load Cells/LC4_PREC: R36.1, R39.2, R41.1, TP23.1, U6.6 (Vout)
/Load Cells/SPI_CLK: ADC1.13 (CLK); also elsewhere on the board
/Load Cells/SPI_MISO: ADC1.12 (Dout); also elsewhere on the board
/Load Cells/SPI_MOSI: ADC1.11 (Din); also elsewhere on the board
GND: ADC1.9 (DGND), ADC1.14 (AGND), C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C18.1, D14.2 (A), D17.2 (A), D19.2 (A), D21.2 (A), D23.2 (A), D25.2 (A), D27.2 (A), D29.2 (A), J3.4, J3.8, J4.4, J4.8, R47.2, R49.2, R51.2, R53.2, RV1.3, RV2.3, RV3.3, RV4.3, U3.4 (Vss), U4.4 (Vss), U5.4 (Vss), U6.4 (Vss), U7.11 (V-); also elsewhere on the board
unnamed: ADC1.5 (CH4), J5.5
unnamed: ADC1.6 (CH5), J5.6
unnamed: ADC1.7 (CH6), J5.7
unnamed: ADC1.8 (CH7), J5.8
unnamed: C8.1, R42.2, U7.3 (+)
unnamed: C9.1, R43.2, U7.5 (+)
unnamed: C11.1, R44.2, U7.10 (+)
unnamed: C12.1, R45.2, U7.12 (+)
unnamed: C14.1, R37.2, R42.1
unnamed: C15.1, R38.2, R43.1
unnamed: C16.1, R40.2, R44.1
unnamed: C17.1, R41.2, R45.1
unnamed: R30.2, U3.1 (Vfg)
unnamed: R31.2, U4.1 (Vfg)
unnamed: R32.2, U5.1 (Vfg)
unnamed: R33.1, RV1.2, U3.5 (Vref)
unnamed: R34.1, RV2.2, U4.5 (Vref)
unnamed: R35.1, RV3.2, U5.5 (Vref)
unnamed: R36.2, U6.1 (Vfg)
unnamed: R39.1, RV4.2, U6.5 (Vref)
unnamed: R46.2, R47.1, U7.2 (-)
unnamed: R48.2, R49.1, U7.6 (-)
unnamed: R50.2, R51.1, U7.9 (-)
unnamed: R52.2, R53.1, U7.13 (-)

Notes on the sheet:
Instrumentation amps
Anti-aliasing

Parts:
D2, D4, D6, D7, D8, D13: CDBA340-HF; D_SMA
F1, F2, F3, F4, F5, F6: 178.6165; 17861650002
J1: Screw_Terminal_01x10
J2: Screw_Terminal_01x04; 1190365
LED1, LED3, LED5, LED7, LED9, LED11: BLU; LED_1206_3216Metric
LED2, LED4, LED6, LED8, LED10, LED12: YLW; LED_1206_3216Metric
Q1, Q2, Q3, Q4, Q5, Q6: FQP30N06; TO-220-3_Vertical
R6, R9, R16, R17, R18, R19, R20, R21, R26, R27, R28, R29: 510; R_1206_3216Metric
R7, R10, R12, R13, R22, R24: DNP; R_1206_3216Metric
R8, R11, R14, R15, R23, R25: 10k; R_1206_3216Metric
TP6, TP7, TP8, TP9, TP10, TP11: TestPoint; TestPoint_Pad_D2.0mm

Connections:
+12V: F1.1, F2.1, F3.1, F4.1, F5.1, F6.1, J2.1, R7.1, R10.1, R12.1, R13.1, R22.1, R24.1; also elsewhere on the board
/Drivers/DRV1_NEG: D13.2 (A), J1.2, Q1.2 (D), R6.2
/Drivers/DRV1_POS: D13.1 (K), F1.2, J1.1, LED1.2 (A), LED2.2 (A)
/Drivers/DRV2_NEG: D2.2 (A), J1.4, Q2.2 (D), R19.2
/Drivers/DRV2_POS: D2.1 (K), F2.2, J1.3, LED3.2 (A), LED4.2 (A)
/Drivers/DRV3_NEG: D4.2 (A), J1.6, Q3.2 (D), R20.2
/Drivers/DRV3_POS: D4.1 (K), F3.2, J1.5, LED5.2 (A), LED6.2 (A)
/Drivers/DRV4_NEG: D6.2 (A), J1.8, Q4.2 (D), R21.2
/Drivers/DRV4_POS: D6.1 (K), F4.2, J1.7, LED7.2 (A), LED8.2 (A)
/Drivers/DRV5_NEG: D7.2 (A), J1.10, Q5.2 (D), R28.2
/Drivers/DRV5_POS: D7.1 (K), F5.2, J1.9, LED9.2 (A), LED10.2 (A)
/Drivers/DRV6_NEG: D8.2 (A), J2.3, Q6.2 (D), R29.2
/Drivers/DRV6_POS: D8.1 (K), F6.2, J2.2, LED11.2 (A), LED12.2 (A)
/Drivers/DRV_CTL_1: Q1.1 (G), R12.2, R15.1, TP6.1; also elsewhere on the board
/Drivers/DRV_CTL_2: Q2.1 (G), R7.2, R8.1, TP7.1; also elsewhere on the board
/Drivers/DRV_CTL_3: Q3.1 (G), R10.2, R11.1, TP8.1; also elsewhere on the board
/Drivers/DRV_CTL_4: Q4.1 (G), R13.2, R14.1, TP9.1; also elsewhere on the board
/Drivers/DRV_CTL_5: Q5.1 (G), R22.2, R23.1, TP10.1; also elsewhere on the board
/Drivers/DRV_CTL_6: Q6.1 (G), R24.2, R25.1, TP11.1; also elsewhere on the board
GND: J2.4, Q1.3 (S), Q2.3 (S), Q3.3 (S), Q4.3 (S), Q5.3 (S), Q6.3 (S), R8.2, R9.2, R11.2, R14.2, R15.2, R16.2, R17.2, R18.2, R23.2, R25.2, R26.2, R27.2; also elsewhere on the board
unnamed: LED1.1 (K), R9.1
unnamed: LED2.1 (K), R6.1
unnamed: LED3.1 (K), R16.1
unnamed: LED4.1 (K), R19.1
unnamed: LED5.1 (K), R17.1
unnamed: LED6.1 (K), R20.1
unnamed: LED7.1 (K), R18.1
unnamed: LED8.1 (K), R21.1
unnamed: LED9.1 (K), R26.1
unnamed: LED10.1 (K), R28.1
unnamed: LED11.1 (K), R27.1
unnamed: LED12.1 (K), R29.1

Notes on the sheet:
Driver 6 is for ignition and has extra connectors for powering the ignition relay.

Parts:
ADC2: MCP3208-CI/SL; SOIC-16_3.9x9.9mm_P1.27mm
C19, C33: 100n; C_1206_3216Metric
C25, C26, C27, C28, C29, C30, C31, C32: 1n; C_1206_3216Metric
D10, D11, D12, D16, D34, D35, D36, D37, D38, D39, D40, D41: CDBA340-HF; D_SMA
J6: Screw_Terminal_01x08; 1190370
J7: Conn_01x08_Female; PinSocket_1x08_P2.54mm_Vertical
R66, R67, R68, R69, R76, R77, R78, R79: 68k; R_1206_3216Metric
R70, R72, R80, R82: 22; R_1206_3216Metric
R71, R73, R81, R83: 47k; R_1206_3216Metric
R74, R75, R84, R85: 5.1k; R_1206_3216Metric
TP24, TP25, TP26, TP27: TestPoint; TestPoint_Pad_D2.0mm
U11: LM324DT; SOIC-14_3.9x8.7mm_P1.27mm

Connections:
+5V: ADC2.15 (Vref), ADC2.16 (Vdd), C19.2, D10.1 (K), D11.1 (K), D12.1 (K), D16.1 (K); also elsewhere on the board
+10V: C33.1, D34.1 (K), D36.1 (K), D38.1 (K), D40.1 (K), J6.1, J6.3, J6.5, J6.7, U11.4 (V+); also elsewhere on the board
/Load Cells/SPI_CLK: ADC2.13 (CLK); also elsewhere on the board
/Load Cells/SPI_MISO: ADC2.12 (Dout); also elsewhere on the board
/Load Cells/SPI_MOSI: ADC2.11 (Din); also elsewhere on the board
/PT Amplification/CS: ADC2.10 (~CS/SHDN); also elsewhere on the board
/PT Amplification/PT1-: D34.2 (A), D35.1 (K), J6.2, R68.2, R72.2, TP25.1
/PT Amplification/PT1_CAL: ADC2.1 (CH0), C26.2, D11.2 (A), J7.1, R73.1, U11.1
/PT Amplification/PT2-: D36.2 (A), D37.1 (K), J6.4, R66.2, R70.2, TP26.1
/PT Amplification/PT2_CAL: ADC2.2 (CH1), C25.2, D16.2 (A), J7.2, R71.1, U11.7
/PT Amplification/PT3-: D38.2 (A), D39.1 (K), J6.6, R76.2, R80.2, TP27.1
/PT Amplification/PT3_CAL: ADC2.3 (CH2), C29.2, D10.2 (A), J7.3, R81.1, U11.8
/PT Amplification/PT4-: D40.2 (A), D41.1 (K), J6.8, R78.2, R82.2, TP24.1
/PT Amplification/PT4_CAL: ADC2.4 (CH3), C30.2, D12.2 (A), J7.4, R83.1, U11.14
GND: ADC2.9 (DGND), ADC2.14 (AGND), C19.1, C27.2, C28.2, C31.2, C32.2, C33.2, D35.2 (A), D37.2 (A), D39.2 (A), D41.2 (A), R70.1, R72.1, R74.2, R75.2, R80.1, R82.1, R84.2, R85.2, U11.11 (V-); also elsewhere on the board
unnamed: ADC2.5 (CH4), J7.5
unnamed: ADC2.6 (CH5), J7.6
unnamed: ADC2.7 (CH6), J7.7
unnamed: ADC2.8 (CH7), J7.8
unnamed: C25.1, R66.1, R67.2
unnamed: C26.1, R68.1, R69.2
unnamed: C27.1, R67.1, U11.5 (+)
unnamed: C28.1, R69.1, U11.3 (+)
unnamed: C29.1, R76.1, R77.2
unnamed: C30.1, R78.1, R79.2
unnamed: C31.1, R77.1, U11.10 (+)
unnamed: C32.1, R79.1, U11.12 (+)
unnamed: R71.2, R74.1, U11.6 (-)
unnamed: R73.2, R75.1, U11.2 (-)
unnamed: R81.2, R84.1, U11.9 (-)
unnamed: R83.2, R85.1, U11.13 (-)

Board: 4 copper layers, 266.7 x 165.1 mm, 239 parts (0 on the bottom side), 121 nets.

## Commit log

2022-09-14 Half complete regulator schematic to start working off of
2022-09-14 unfuck git setup
2022-09-14 i am very smart. no person can match my intellectual prowess. chinese pcb manufacturers tremble before me
2022-09-18 secret arca meetings
2022-09-18 Added pages
2022-09-25 first revision of full schematic copied over
2022-09-25 added schematic pdf for review
2022-10-17 added footprints and started schematic review revisions
2022-10-20 schematic editing + creating some footprints
2022-10-23 updated all footprints, resolved most ERC & setup layout
2022-10-27 grouped components on PCB
2022-11-07 preliminary layout and started pwr plane config
2022-11-17 fixed pwr planes
2022-12-17 some minor schematic cleanup
2022-12-17 shuffle around some parts
2022-12-17 add overvoltage diodes
2022-12-17 positioning for LC connectors
2022-12-17 complete arrangement for load cells
2022-12-18 laid out ignition and PTs
2022-12-18 nearly done with part layout
2022-12-18 finish putting shit together
2022-12-18 copper pours done
2022-12-18 starting on routing
2022-12-19 mostly finished routing
2022-12-19 cleaned up bad hole sizes but now there are interferences
2022-12-19 done routing
2022-12-19 add autosave files to gitignore
2022-12-19 done with routing
2022-12-19 remove unused things
2022-12-19 not sure if anything has changed but this is the last commit before moving to two LCs
2022-12-20 enshrinkening of the board
2022-12-20 done routing on shrunk board
2022-12-23 create documentation and license
2022-12-23 creating SVGs for documentation
2022-12-23 attempt to fix up github image rendering
2022-12-23 figured out images perfectly now
2022-12-23 remove sheet borders from schematic pictures
2022-12-23 add some docs data collection
2022-12-24 add karca render to documentation
2022-12-27 done schematiccing after design review
2022-12-27 cleaned up PT footprint
2022-12-28 waiting on mouser for footprints
2022-12-28 ready for fab
2022-12-29 solid fill for current paths
2022-12-29 final rev for jlc
2022-12-29 possible fix for output impedance on load cell reference voltage; not yet in PCB
2023-01-03 started on opamp arrangement
2023-01-03 fix routinggit add -A
2023-01-03 my body is a machine that takes in peanut m&ms and puts out rocket engine controllers
2023-01-08 add incomplete bom
2023-01-10 create fab data for karca
2023-01-10 add csvs to fab outputs
2023-01-10 updated bom with box stuff
2023-01-10 added lp20 connectors to karca bom
2023-01-10 added jd1912 type relay for ignition to karca bom
2023-01-10 karca BOM done
2023-01-12 updated load cell count to 4
2023-01-19 update karca to match what was sent out to JLC
2023-01-19 make karca pcb blue
2023-01-19 clean up unused libraries
2023-01-20 add wiring tables for XLR connectors
2023-01-24 create lessons learned doc:
2023-01-27 add notes on router-smoking
2023-01-30 update lessons with new findings from running slonk
2023-02-01 update lessons with some notes on R2R opamps
2023-02-01 add notes on making more amps for PTs
2023-02-02 improve note on wire wiggle in lessons
2023-02-05 resolve PT instability issue in lessons
2023-02-13 move to kicad 7.0
2023-03-02 add notes on valve drivers
2023-03-02 create simple controller startup procedure in manual
2023-03-02 create manual procedure for powering on the router
