File: regulators.kicad_sch (KiCad schematic)
At the start: 20 parts

Commit message: secret arca meetings
Parts:
- added J? (x6): Conn_01x01_Male, symbol Connector:Conn_01x01_Male
- added J?: Conn_01x04, symbol Connector_Generic:Conn_01x04
Connections:
- net +10V: now also J?.1 (Pin_1)
- net +12V: now also J?.1 (Pin_1), J?.1 (Pin_1)
- net +5V: now also J?.3 (Pin_3)
- net GND: now also J?.1 (Pin_1), J?.1 (Pin_1), J?.1 (Pin_1), J?.2 (Pin_2), J?.4 (Pin_4)
- net at SW?.1 (A): now also J?.1 (Pin_1)
- no-connect marks 0 -> 2

Commit message: Added pages
Changed lines of the file:
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@@
   )
   (symbol (lib_id "Device:D_Schottky") (at 129.54 72.39 0) (unit 1)
-    (in_bom yes) (on_board yes) (fields_autoplaced)
-    (property "Reference" "D?" (id 0) (at 129.2225 68.58 0))
+    (in_bom yes) (on_board yes)
+    (property "Reference" "D?" (id 0) (at 129.54 69.85 0))
     (property "Value" "D_Schottky" (id 1) (at 129.2225 68.58 0)
       (effects (font (size 1.27 1.27)) hide)

Commit message: first revision of full schematic copied over
Parts:
- removed J? (x6): Conn_01x01_Male, symbol Connector:Conn_01x01_Male
- added J?: CONN_BATTERY_1, symbol Connector:Conn_01x01_Male
- added J? (x3): Conn_01x02_Male, symbol Connector:Conn_01x02_Male
- added J?: CON_BATTERY_2, symbol Connector:Conn_01x01_Male
Connections:
- net +12V: now also J?.1 (Pin_1), J?.1 (Pin_1)
- net 12V_CON: now also J?.1 (Pin_1)
- net GND: now also J?.1 (Pin_1), J?.2 (Pin_2), J?.2 (Pin_2), J?.2 (Pin_2)
- net at SW?.1 (A): now also J?.1 (Pin_1)
Other:
- company: (none) -> Rice Eclipse
- title: (none) -> Voltage Regulators
- moved on the sheet: BT?, SW?

Commit message: added schematic pdf for review
Parts:
- gave numbers to parts that had none: 26

Commit message: added footprints and started schematic review revisions
Parts:
- removed BT1: Battery, symbol Device:Battery
- removed J3, J4, J5: Conn_01x02_Male, symbol Connector:Conn_01x02_Male
- added J3, J4, J5: Conn_01x02_Female, symbol Connector:Conn_01x02_Female
- D1: value DO-201 -> 1N5822RLG; footprint (none) -> Diode_THT:D_DO-201AD_P15.24mm_Horizontal
- D2, D5, D6: footprint (none) -> LED_SMD:LED_1206_3216Metric
- D3, D4: value D_Schottky -> SS54; footprint (none) -> karca_custom_footprints:DO-214AC
- J1: value CONN_BATTERY_1 -> CON_BATTERY_1
- R1: footprint (none) -> Resistor_SMD:R_1206_3216Metric
- U2: footprint (none) -> Package_TO_SOT_SMD:TO-263-3_TabPin2
Connections:
- net +12V: now also J3.1 (Pin_1), J5.1 (Pin_1)
- net GND: now also J3.2 (Pin_2), J4.2 (Pin_2), J5.2 (Pin_2)
- net at SW2.1 (A): now also J4.1 (Pin_1)
