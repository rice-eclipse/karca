File: regulators.kicad_sch (KiCad schematic)
At the start: 24 parts, among them J1 Conn_01x02_Female, J2 Conn_01x02_Female, J3 Conn_01x02_Female, J4 Conn_01x04_Female, J5 Conn_01x02_Female, SW1 1101M2S3CQE2, SW2 1101M2S3CQE2, U1 LM1084-ADJ, U2 LM1084-5.0

Commit message: preliminary layout and started pwr plane config
Parts:
- removed J1, J2, J3, J5: Conn_01x02_Female, Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical, symbol Connector:Conn_01x02_Female
- added J2, J3, J4, J5: Screw_Terminal_01x02, 1190363:1190363, symbol Connector:Screw_Terminal_01x02
- renumbered C2 to C1, C4 to C2, C1 to C3, C3 to C4, D6 to D4, D4 to D5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
Connections:
- net +12V: now also J3.1 (Pin_1), J4.1 (Pin_1)
- net 12V_CON: now also J5.1 (Pin_1)
- net GND: now also J2.2 (Pin_2), J3.2 (Pin_2), J4.2 (Pin_2), J5.2 (Pin_2)
- net at SW1.1 (A): now also J2.1 (Pin_1)

Commit message: some minor schematic cleanup
Parts:
- C1, C2, C3, C4: value 10uF -> 10u
Changed lines of the file:
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@@
-    (effects (font (size 1.27 1.27)) (justify left bottom))
-  )
-  (label "5V_REG" (at 153.67 128.27 0)
-    (effects (font (size 1.27 1.27)) (justify left bottom))
-  )
-  (label "10V_REG" (at 152.4 83.82 0)
     (effects (font (size 1.27 1.27)) (justify left bottom))
   )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Datasheet" "https://www.phoenixcontact.com/en-us/products/printed-circuit-board-terminal-lpta-25-2-50-1190363" (id 3) (at 162.56 43.18 0)
+    (property "Datasheet" "~" (id 3) (at 162.56 43.18 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Datasheet" "https://www.phoenixcontact.com/en-us/products/printed-circuit-board-terminal-lpta-25-2-50-1190363" (id 3) (at 133.35 58.42 0)
+    (property "Datasheet" "~" (id 3) (at 133.35 58.42 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Datasheet" "https://datasheet.lcsc.com/lcsc/2006301532_Yongyu-Photoelectric-SZYY1206R_C434438.pdf" (id 3) (at 92.71 63.5 0)
+    (property "Datasheet" "~" (id 3) (at 92.71 63.5 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Value" "10uF" (id 1) (at 119.38 134.6199 0)
+    (property "Value" "10u" (id 1) (at 119.38 134.6199 0)
       (effects (font (size 1.27 1.27)) (justify left))
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Datasheet" "https://datasheet.lcsc.com/lcsc/2006301532_Yongyu-Photoelectric-SZYY1206R_C434438.pdf" (id 3) (at 162.56 88.9 0)
+    (property "Datasheet" "~" (id 3) (at 162.56 88.9 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Datasheet" "https://www.mouser.com/datasheet/2/240/1000-3050429.pdf" (id 3) (at 66.04 68.58 0)
+    (property "Datasheet" "~" (id 3) (at 66.04 68.58 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Value" "10uF" (id 1) (at 114.3 91.44 0)
+    (property "Value" "10u" (id 1) (at 114.3 91.44 0)
       (effects (font (size 1.27 1.27)) (justify left))
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Datasheet" "https://media.digikey.com/pdf/Data%20Sheets/NextGen%20Components%20PDFs/SMASS540000S54.pdf" (id 3) (at 129.54 72.39 0)
+    (property "Datasheet" "~" (id 3) (at 129.54 72.39 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Datasheet" "https://www.mouser.com/datasheet/2/240/1000-3050429.pdf" (id 3) (at 133.35 45.72 0)
+    (property "Datasheet" "~" (id 3) (at 133.35 45.72 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Datasheet" "https://www.phoenixcontact.com/en-us/products/printed-circuit-board-terminal-lpta-25-2-50-1190363" (id 3) (at 43.18 62.23 0)
+    (property "Datasheet" "~" (id 3) (at 43.18 62.23 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Datasheet" "https://www.phoenixcontact.com/en-us/products/printed-circuit-board-terminal-lpta-25-2-50-1190363" (id 3) (at 194.31 60.96 0)
+    (property "Datasheet" "~" (id 3) (at 194.31 60.96 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Datasheet" "https://datasheet.lcsc.com/lcsc/2006301532_Yongyu-Photoelectric-SZYY1206R_C434438.pdf" (id 3) (at 151.13 133.35 0)
+    (property "Datasheet" "~" (id 3) (at 151.13 133.35 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Datasheet" "https://media.digikey.com/pdf/Data%20Sheets/NextGen%20Components%20PDFs/SMASS540000S54.pdf" (id 3) (at 129.54 118.11 0)
+    (property "Datasheet" "~" (id 3) (at 129.54 118.11 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Value" "10uF" (id 1) (at 154.94 90.17 0)
+    (property "Value" "10u" (id 1) (at 154.94 90.17 0)
       (effects (font (size 1.27 1.27)) (justify left))
     )
@@
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Value" "10uF" (id 1) (at 144.78 134.6199 0)
-      (effects (font (size 1.27 1.27)) (justify left))
-    )
+    (property "Value" "10u" (id 1) (at 144.78 134.6199 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )

Commit message: shuffle around some parts
Parts:
- removed SW1, SW2: 1101M2S3CQE2, 1101M2S3CQE2:SW_1101M2S3CQE2, symbol Switch:SW_SPDT
- added SW1, SW2: S101031MS02Q, S101031MS02Q:S101031MS02Q, symbol Switch:SW_SPST
- LED_10V1: renamed from D4; value PWR_10V -> RED
- LED_12V1: renamed from D2; value PWR_12V -> RED
- LED_5V1: renamed from D6; value PWR_5V -> RED
- renumbered J5 to J1, J1 to J5
Connections:
- net +12V: now also SW2.1 (A)
- net 12V_CON: now also SW1.1 (A)
- net at J2.1 (Pin_1): now also SW2.2 (B)
- net at D1.2 (A): now also SW1.2 (B)
- no-connect marks 2 -> 0
Other:
- note added: "BATTERY"
- note added: "FAN"
- note added: "IGNITION RELAY"
- note added: "ROUTER"
- moved on the sheet: J1, J2, J3, J4

Commit message: laid out ignition and PTs
Parts:
- D3, D5: value SS54 -> DO-214AC
- renumbered J1 to CON_BAT1, J2 to CON_FAN1, J4 to CON_IGN_12, J3 to CON_ROUTER1
Changed lines of the file:
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@@
   (symbol (lib_id "Connector:Screw_Terminal_01x02") (at 132.715 27.94 0) (unit 1)
     (in_bom yes) (on_board yes) (fields_autoplaced)
-    (property "Reference" "J2" (id 0) (at 135.255 27.9399 0)
+    (property "Reference" "CON_FAN1" (id 0) (at 135.89 29.2099 0)
       (effects (font (size 1.27 1.27)) (justify left))
     )
@@
   (symbol (lib_id "Connector:Screw_Terminal_01x02") (at 119.38 58.42 0) (unit 1)
     (in_bom yes) (on_board yes)
-    (property "Reference" "J3" (id 0) (at 121.92 59.6899 0)
+    (property "Reference" "CON_ROUTER1" (id 0) (at 121.92 59.6899 0)
       (effects (font (size 1.27 1.27)) (justify left))
     )
@@
     (in_bom yes) (on_board yes)
     (property "Reference" "D3" (id 0) (at 129.54 69.85 0))
-    (property "Value" "SS54" (id 1) (at 129.2225 68.58 0)
+    (property "Value" "DO-214AC" (id 1) (at 129.2225 68.58 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
   (symbol (lib_id "Connector:Screw_Terminal_01x02") (at 43.18 59.69 0) (mirror y) (unit 1)
     (in_bom yes) (on_board yes) (fields_autoplaced)
-    (property "Reference" "J1" (id 0) (at 43.18 55.88 0))
+    (property "Reference" "CON_BAT1" (id 0) (at 43.18 55.88 0))
     (property "Value" "Screw_Terminal_01x02" (id 1) (at 40.64 62.2299 0)
       (effects (font (size 1.27 1.27)) (justify left) hide)
@@
   (symbol (lib_id "Connector:Screw_Terminal_01x02") (at 120.015 43.18 0) (unit 1)
     (in_bom yes) (on_board yes)
-    (property "Reference" "J4" (id 0) (at 122.555 44.4499 0)
+    (property "Reference" "CON_IGN_12" (id 0) (at 122.555 44.4499 0)
       (effects (font (size 1.27 1.27)) (justify left))
     )
@@
     (in_bom yes) (on_board yes) (fields_autoplaced)
     (property "Reference" "D5" (id 0) (at 129.2225 114.3 0))
-    (property "Value" "SS54" (id 1) (at 129.2225 114.3 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
+    (property "Value" "DO-214AC" (id 1) (at 129.2225 114.3 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )

Commit message: starting on routing
Connections:
- net FAN_PWR: now reaches CON_FAN1.1 (Pin_1), SW2.2 (B)
- net 12V_PRERECT: now reaches D1.2 (A), SW1.2 (B)
Other:
- moved on the sheet: CON_BAT1, CON_FAN1, D1, SW1
Changed lines of the file:
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@@
   (junction (at 105.41 27.94) (diameter 0) (color 0 0 0 0)
   )
-  (junction (at 48.26 73.66) (diameter 0) (color 0 0 0 0)
+  (junction (at 41.275 73.66) (diameter 0) (color 0 0 0 0)
   )
   (junction (at 105.41 72.39) (diameter 0) (color 0 0 0 0)
@@
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
-  (wire (pts (xy 48.26 73.66) (xy 46.99 73.66))
+  (wire (pts (xy 41.275 73.66) (xy 40.005 73.66))
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
@@
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
-  (wire (pts (xy 85.09 59.69) (xy 92.71 59.69))
+  (wire (pts (xy 83.185 59.69) (xy 92.71 59.69))
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
@@
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
-  (wire (pts (xy 125.095 27.94) (xy 127.635 27.94))
+  (wire (pts (xy 125.095 27.94) (xy 134.62 27.94))
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
@@
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
-  (wire (pts (xy 48.26 77.47) (xy 48.26 73.66))
-    (stroke (width 0) (type default) (color 0 0 0 0))
-  )
-  (wire (pts (xy 48.26 59.69) (xy 60.96 59.69))
+  (wire (pts (xy 41.275 77.47) (xy 41.275 73.66))
+    (stroke (width 0) (type default) (color 0 0 0 0))
+  )
+  (wire (pts (xy 41.275 59.69) (xy 53.975 59.69))
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
@@
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
-  (wire (pts (xy 71.12 59.69) (xy 77.47 59.69))
+  (wire (pts (xy 64.135 59.69) (xy 75.565 59.69))
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
@@
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
-  (wire (pts (xy 48.26 62.23) (xy 48.26 73.66))
+  (wire (pts (xy 41.275 62.23) (xy 41.275 73.66))
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
@@
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
-  (wire (pts (xy 126.365 30.48) (xy 127.635 30.48))
+  (wire (pts (xy 126.365 30.48) (xy 134.62 30.48))
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
@@
     (effects (font (size 1.27 1.27)) (justify left bottom))
   )
-  (text "BATTERY" (at 39.37 66.04 0)
+  (text "BATTERY" (at 32.385 66.04 0)
     (effects (font (size 1.27 1.27)) (justify left bottom))
   )
-  (text "FAN" (at 131.445 26.035 0)
+  (text "FAN" (at 138.43 26.035 0)
     (effects (font (size 1.27 1.27)) (justify left bottom))
   )
@@
     (effects (font (size 1.27 1.27)) (justify left bottom))
   )
-  (label "12V_CON" (at 59.69 59.69 180)
+  (label "12V_CON" (at 52.705 59.69 180)
     (effects (font (size 1.27 1.27)) (justify right bottom))
+  )
+  (label "12V_PRERECT" (at 64.135 59.69 0)
+    (effects (font (size 1.27 1.27)) (justify left bottom))
   )
   (label "10V_FB" (at 133.35 93.98 0)
     (effects (font (size 1.27 1.27)) (justify left bottom))
   )
-  (symbol (lib_id "Connector:Screw_Terminal_01x02") (at 132.715 27.94 0) (unit 1)
-    (in_bom yes) (on_board yes) (fields_autoplaced)
-    (property "Reference" "CON_FAN1" (id 0) (at 135.89 29.2099 0)
-      (effects (font (size 1.27 1.27)) (justify left))
-    )
-    (property "Value" "Screw_Terminal_01x02" (id 1) (at 135.255 30.4799 0)
+  (label "FAN_PWR" (at 125.73 27.94 0)
+    (effects (font (size 1.27 1.27)) (justify left bottom))
+  )
+  (symbol (lib_id "Connector:Screw_Terminal_01x02") (at 139.7 27.94 0) (unit 1)
+    (in_bom yes) (on_board yes) (fields_autoplaced)
+    (property "Reference" "CON_FAN1" (id 0) (at 142.875 29.2099 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Value" "Screw_Terminal_01x02" (id 1) (at 142.24 30.4799 0)
       (effects (font (size 1.27 1.27)) (justify left) hide)
     )
-    (property "Footprint" "1190363:1190363" (id 2) (at 132.715 27.94 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Datasheet" "~" (id 3) (at 132.715 27.94 0)
+    (property "Footprint" "1190363:1190363" (id 2) (at 139.7 27.94 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "~" (id 3) (at 139.7 27.94 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
     (pin "1")
   )
-  (symbol (lib_id "power:PWR_FLAG") (at 46.99 73.66 90) (unit 1)
-    (in_bom yes) (on_board yes) (fields_autoplaced)
-    (property "Reference" "#FLG02" (id 0) (at 45.085 73.66 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Value" "PWR_FLAG" (id 1) (at 43.815 73.6599 90)
-      (effects (font (size 1.27 1.27)) (justify left))
-    )
-    (property "Footprint" "" (id 2) (at 46.99 73.66 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Datasheet" "~" (id 3) (at 46.99 73.66 0)
+  (symbol (lib_id "power:PWR_FLAG") (at 40.005 73.66 90) (unit 1)
+    (in_bom yes) (on_board yes) (fields_autoplaced)
+    (property "Reference" "#FLG02" (id 0) (at 38.1 73.66 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Value" "PWR_FLAG" (id 1) (at 36.83 73.6599 90)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Footprint" "" (id 2) (at 40.005 73.66 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "~" (id 3) (at 40.005 73.66 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
     (pin "2")
   )
-  (symbol (lib_id "Connector:Screw_Terminal_01x02") (at 43.18 59.69 0) (mirror y) (unit 1)
-    (in_bom yes) (on_board yes) (fields_autoplaced)
-    (property "Reference" "CON_BAT1" (id 0) (at 43.18 55.88 0))
-    (property "Value" "Screw_Terminal_01x02" (id 1) (at 40.64 62.2299 0)
+  (symbol (lib_id "Connector:Screw_Terminal_01x02") (at 36.195 59.69 0) (mirror y) (unit 1)
+    (in_bom yes) (on_board yes) (fields_autoplaced)
+    (property "Reference" "CON_BAT1" (id 0) (at 36.195 55.88 0))
+    (property "Value" "Screw_Terminal_01x02" (id 1) (at 33.655 62.2299 0)
       (effects (font (size 1.27 1.27)) (justify left) hide)
     )
-    (property "Footprint" "1190363:1190363" (id 2) (at 43.18 59.69 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Datasheet" "~" (id 3) (at 43.18 59.69 0)
+    (property "Footprint" "1190363:1190363" (id 2) (at 36.195 59.69 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "~" (id 3) (at 36.195 59.69 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
     (pin "1")
   )
-  (symbol (lib_id "Device:D") (at 81.28 59.69 180) (unit 1)
-    (in_bom yes) (on_board yes) (fields_autoplaced)
-    (property "Reference" "D1" (id 0) (at 81.28 52.705 0))
-    (property "Value" "1N5822RLG" (id 1) (at 81.28 55.245 0))
-    (property "Footprint" "Diode_THT:D_DO-201AD_P15.24mm_Horizontal" (id 2) (at 81.28 59.69 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Datasheet" "~" (id 3) (at 81.28 59.69 0)
+  (symbol (lib_id "Device:D") (at 79.375 59.69 180) (unit 1)
+    (in_bom yes) (on_board yes) (fields_autoplaced)
+    (property "Reference" "D1" (id 0) (at 79.375 52.705 0))
+    (property "Value" "1N5822RLG" (id 1) (at 79.375 55.245 0))
+    (property "Footprint" "Diode_THT:D_DO-201AD_P15.24mm_Horizontal" (id 2) (at 79.375 59.69 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "~" (id 3) (at 79.375 59.69 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
     (pin "1")
   )
-  (symbol (lib_id "power:GND") (at 48.26 77.47 0) (unit 1)
-    (in_bom yes) (on_board yes) (fields_autoplaced)
-    (property "Reference" "#PWR011" (id 0) (at 48.26 83.82 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Value" "GND" (id 1) (at 48.26 81.915 0))
-    (property "Footprint" "" (id 2) (at 48.26 77.47 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Datasheet" "" (id 3) (at 48.26 77.47 0)
+  (symbol (lib_id "power:GND") (at 41.275 77.47 0) (unit 1)
+    (in_bom yes) (on_board yes) (fields_autoplaced)
+    (property "Reference" "#PWR011" (id 0) (at 41.275 83.82 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Value" "GND" (id 1) (at 41.275 81.915 0))
+    (property "Footprint" "" (id 2) (at 41.275 77.47 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "" (id 3) (at 41.275 77.47 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Value" "PWR_FLAG" (id 1) (at 93.98 55.88 0))
+    (property "Value" "PWR_FLAG" (id 1) (at 92.71 55.245 0))
     (property "Footprint" "" (id 2) (at 92.71 59.69 0)
       (effects (font (size 1.27 1.27)) hide)
@@
     (pin "2")
   )
-  (symbol (lib_id "Switch:SW_SPST") (at 66.04 59.69 0) (unit 1)
-    (in_bom yes) (on_board yes) (fields_autoplaced)
-    (property "Reference" "SW1" (id 0) (at 66.04 53.34 0))
-    (property "Value" "S101031MS02Q" (id 1) (at 66.04 55.88 0))
-    (property "Footprint" "S101031MS02Q:S101031MS02Q" (id 2) (at 66.04 59.69 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Datasheet" "~" (id 3) (at 66.04 59.69 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
+  (symbol (lib_id "Switch:SW_SPST") (at 59.055 59.69 0) (unit 1)
+    (in_bom yes) (on_board yes) (fields_autoplaced)
+    (property "Reference" "SW1" (id 0) (at 59.055 53.34 0))
+    (property "Value" "S101031MS02Q" (id 1) (at 59.055 55.88 0))
+    (property "Footprint" "S101031MS02Q:S101031MS02Q" (id 2) (at 59.055 59.69 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "~" (id 3) (at 59.055 59.69 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )

Commit message: not sure if anything has changed but this is the last commit before moving to two LCs
Parts:
- J5: footprint Connector_PinHeader_2.54mm:PinHeader_1x04_P2.54mm_Vertical -> Connector_PinSocket_2.54mm:PinSocket_1x04_P2.54mm_Vertical
Changed lines of the file:
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@@
       (effects (font (size 1.27 1.27)) (justify left) hide)
     )
-    (property "Footprint" "Connector_PinHeader_2.54mm:PinHeader_1x04_P2.54mm_Vertical" (id 2) (at 196.85 39.37 0)
+    (property "Footprint" "Connector_PinSocket_2.54mm:PinSocket_1x04_P2.54mm_Vertical" (id 2) (at 196.85 39.37 0)
       (effects (font (size 1.27 1.27)) hide)
     )
