File: lc_inamps.kicad_sch (KiCad schematic)
At the start: 44 parts, among them J19 Conn_01x06_Female, J20 Conn_02x06_Odd_Even, U3 MCP6N11, U4 MCP6N11, U5 MCP6N11, U6 MCP6N11, U7 MCP6N11, U8 MCP6N11

Commit message: complete arrangement for load cells
Parts:
- added J?: Conn_01x02_Female, Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical, symbol Connector:Conn_01x02_Female
- J19: symbol Connector:Conn_01x06_Female -> Connector:Conn_01x04_Female
Connections:
- net LC5_PREC: now also J?.1 (Pin_1); no longer J19.5 (Pin_5)
- net LC6_PREC: now also J?.2 (Pin_2); no longer J19.6 (Pin_6)
Other:
- moved on the sheet: J20
Changed lines of the file:
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@@
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
-  (wire (pts (xy 109.22 176.53) (xy 102.87 176.53))
+  (wire (pts (xy 111.76 173.99) (xy 105.41 173.99))
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
@@
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
-  (wire (pts (xy 109.22 171.45) (xy 102.87 171.45))
+  (wire (pts (xy 111.76 168.91) (xy 105.41 168.91))
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
@@
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
-  (wire (pts (xy 83.82 168.91) (xy 90.17 168.91))
+  (wire (pts (xy 86.36 166.37) (xy 92.71 166.37))
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
@@
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
-  (wire (pts (xy 83.82 179.07) (xy 90.17 179.07))
+  (wire (pts (xy 86.36 176.53) (xy 92.71 176.53))
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
@@
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
-  (wire (pts (xy 109.22 168.91) (xy 102.87 168.91))
+  (wire (pts (xy 111.76 166.37) (xy 105.41 166.37))
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
@@
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
-  (wire (pts (xy 83.82 176.53) (xy 90.17 176.53))
+  (wire (pts (xy 86.36 173.99) (xy 92.71 173.99))
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
@@
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
-  (wire (pts (xy 109.22 173.99) (xy 102.87 173.99))
+  (wire (pts (xy 111.76 171.45) (xy 105.41 171.45))
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
@@
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
-  (wire (pts (xy 83.82 173.99) (xy 90.17 173.99))
+  (wire (pts (xy 86.36 171.45) (xy 92.71 171.45))
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
@@
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
-  (wire (pts (xy 83.82 171.45) (xy 90.17 171.45))
+  (wire (pts (xy 86.36 168.91) (xy 92.71 168.91))
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
@@
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
-  (wire (pts (xy 83.82 166.37) (xy 90.17 166.37))
+  (wire (pts (xy 86.36 163.83) (xy 92.71 163.83))
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
@@
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
-  (wire (pts (xy 109.22 166.37) (xy 102.87 166.37))
+  (wire (pts (xy 111.76 163.83) (xy 105.41 163.83))
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
@@
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
-  (wire (pts (xy 109.22 179.07) (xy 102.87 179.07))
+  (wire (pts (xy 111.76 176.53) (xy 105.41 176.53))
     (stroke (width 0) (type default) (color 0 0 0 0))
   )
@@
     (effects (font (size 1.27 1.27)) (justify left bottom))
   )
-  (label "LC3+" (at 83.82 171.45 0)
+  (label "LC3+" (at 86.36 168.91 0)
     (effects (font (size 1.27 1.27)) (justify left bottom))
   )
@@
     (effects (font (size 1.27 1.27)) (justify left bottom))
   )
-  (label "LC6+" (at 83.82 179.07 0)
+  (label "LC6+" (at 86.36 176.53 0)
     (effects (font (size 1.27 1.27)) (justify left bottom))
   )
-  (label "LC5+" (at 83.82 176.53 0)
+  (label "LC5+" (at 86.36 173.99 0)
     (effects (font (size 1.27 1.27)) (justify left bottom))
   )
@@
     (effects (font (size 1.27 1.27)) (justify left bottom))
   )
-  (label "LC3-" (at 109.22 171.45 180)
+  (label "LC3-" (at 111.76 168.91 180)
     (effects (font (size 1.27 1.27)) (justify right bottom))
   )
@@
     (effects (font (size 1.27 1.27)) (justify left bottom))
   )
-  (label "LC1-" (at 109.22 166.37 180)
+  (label "LC1-" (at 111.76 163.83 180)
     (effects (font (size 1.27 1.27)) (justify right bottom))
   )
@@
     (effects (font (size 1.27 1.27)) (justify left bottom))
   )
-  (label "LC2+" (at 83.82 168.91 0)
+  (label "LC2+" (at 86.36 166.37 0)
     (effects (font (size 1.27 1.27)) (justify left bottom))
   )
-  (label "LC5-" (at 109.22 176.53 180)
+  (label "LC5-" (at 111.76 173.99 180)
     (effects (font (size 1.27 1.27)) (justify right bottom))
   )
-  (label "LC4-" (at 109.22 173.99 180)
+  (label "LC4-" (at 111.76 171.45 180)
     (effects (font (size 1.27 1.27)) (justify right bottom))
   )
@@
     (effects (font (size 1.27 1.27)) (justify left bottom))
   )
-  (label "LC2-" (at 109.22 168.91 180)
+  (label "LC2-" (at 111.76 166.37 180)
     (effects (font (size 1.27 1.27)) (justify right bottom))
   )
@@
     (effects (font (size 1.27 1.27)) (justify left bottom))
   )
-  (label "LC6-" (at 109.22 179.07 180)
+  (label "LC6-" (at 111.76 176.53 180)
     (effects (font (size 1.27 1.27)) (justify right bottom))
   )
@@
     (effects (font (size 1.27 1.27)) (justify left bottom))
   )
-  (label "LC4+" (at 83.82 173.99 0)
+  (label "LC4+" (at 86.36 171.45 0)
     (effects (font (size 1.27 1.27)) (justify left bottom))
   )
-  (label "LC1+" (at 83.82 166.37 0)
+  (label "LC1+" (at 86.36 163.83 0)
     (effects (font (size 1.27 1.27)) (justify left bottom))
   )
@@
     )
   )
-  (global_label "LC6_PREC" (shape input) (at 66.04 177.8 180) (fields_autoplaced)
+  (global_label "LC6_PREC" (shape input) (at 66.04 181.61 180) (fields_autoplaced)
     (effects (font (size 1.27 1.27)) (justify right))
-    (property "Intersheet References" "${INTERSHEET_REFS}" (id 0) (at 54.1926 177.7206 0)
+    (property "Intersheet References" "${INTERSHEET_REFS}" (id 0) (at 54.1926 181.5306 0)
       (effects (font (size 1.27 1.27)) (justify right) hide)
     )
   )
-  (global_label "LC5_PREC" (shape input) (at 66.04 175.26 180) (fields_autoplaced)
+  (global_label "LC5_PREC" (shape input) (at 66.04 179.07 180) (fields_autoplaced)
     (effects (font (size 1.27 1.27)) (justify right))
-    (property "Intersheet References" "${INTERSHEET_REFS}" (id 0) (at 54.1926 175.1806 0)
+    (property "Intersheet References" "${INTERSHEET_REFS}" (id 0) (at 54.1926 178.9906 0)
       (effects (font (size 1.27 1.27)) (justify right) hide)
     )
@@
     (pin "1")
   )
-  (symbol (lib_id "Connector:Conn_01x06_Female") (at 71.12 170.18 0) (unit 1)
-    (in_bom yes) (on_board yes)
-    (property "Reference" "J19" (id 0) (at 68.58 161.29 0)
-      (effects (font (size 1.27 1.27)) (justify left))
-    )
-    (property "Value" "Conn_01x06_Female" (id 1) (at 72.39 171.4499 0)
+  (symbol (lib_id "Connector:Conn_01x04_Female") (at 71.12 167.64 0) (unit 1)
+    (in_bom yes) (on_board yes)
+    (property "Reference" "J19" (id 0) (at 67.945 162.56 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Value" "Conn_01x06_Female" (id 1) (at 72.39 168.9099 0)
       (effects (font (size 1.27 1.27)) (justify left) hide)
     )
-    (property "Footprint" "Connector_PinSocket_2.54mm:PinSocket_1x06_P2.54mm_Vertical" (id 2) (at 71.12 170.18 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Datasheet" "~" (id 3) (at 71.12 170.18 0)
+    (property "Footprint" "Connector_PinSocket_2.54mm:PinSocket_1x06_P2.54mm_Vertical" (id 2) (at 71.12 167.64 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "~" (id 3) (at 71.12 167.64 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
     (pin "3")
     (pin "4")
-    (pin "5")
-    (pin "6")
   )
   (symbol (lib_id "power:+5V") (at 212.09 110.49 0) (unit 1)
@@
     (pin "1")
   )
-  (symbol (lib_id "Connector_Generic:Conn_02x06_Odd_Even") (at 95.25 171.45 0) (unit 1)
-    (in_bom yes) (on_board yes) (fields_autoplaced)
-    (property "Reference" "J20" (id 0) (at 96.52 162.56 0))
-    (property "Value" "Conn_02x06_Odd_Even" (id 1) (at 96.52 162.56 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Footprint" "Connector_PinSocket_2.54mm:PinSocket_2x06_P2.54mm_Vertical" (id 2) (at 95.25 171.45 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Datasheet" "~" (id 3) (at 95.25 171.45 0)
+  (symbol (lib_id "Connector_Generic:Conn_02x06_Odd_Even") (at 97.79 168.91 0) (unit 1)
+    (in_bom yes) (on_board yes) (fields_autoplaced)
+    (property "Reference" "J20" (id 0) (at 99.06 160.02 0))
+    (property "Value" "Conn_02x06_Odd_Even" (id 1) (at 99.06 160.02 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Footprint" "Connector_PinSocket_2.54mm:PinSocket_2x06_P2.54mm_Vertical" (id 2) (at 97.79 168.91 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "~" (id 3) (at 97.79 168.91 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
     (pin "1")
   )
+  (symbol (lib_id "Connector:Conn_01x02_Female") (at 71.12 179.07 0) (unit 1)
+    (in_bom yes) (on_board yes) (fields_autoplaced)
+    (property "Reference" "J?" (id 0) (at 72.39 179.0699 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Value" "Conn_01x02_Female" (id 1) (at 72.39 181.6099 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Footprint" "Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical" (id 2) (at 71.12 179.07 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "~" (id 3) (at 71.12 179.07 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "1")
+    (pin "2")
+  )
   (symbol (lib_id "Device:Fuse") (at 36.83 114.3 0) (unit 1)

Commit message: laid out ignition and PTs
Parts:
- gave numbers to parts that had none: 1
Changed lines of the file:
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@@
   (symbol (lib_id "Connector:Conn_01x02_Female") (at 71.12 179.07 0) (unit 1)
     (in_bom yes) (on_board yes) (fields_autoplaced)
-    (property "Reference" "J?" (id 0) (at 72.39 179.0699 0)
+    (property "Reference" "J13" (id 0) (at 72.39 179.0699 0)
       (effects (font (size 1.27 1.27)) (justify left))
     )

Commit message: finish putting shit together
Parts:
- removed F10, F11, F12, F7, F8, F9: 178.6165, 178.6165:17861650002, symbol Device:Fuse
Connections:
- net +5V: now also CON_LC1.1 (Pin_1), CON_LC2.1 (Pin_1), CON_LC3.1 (Pin_1), CON_LC4.1 (Pin_1), CON_LC5.1 (Pin_1), CON_LC6.1 (Pin_1)

Commit message: copper pours done
Connections:
- net +5V: no longer RV1.1, RV2.1, RV3.1, RV4.1, RV5.1, RV6.1
- new net +10V: RV1.1, RV2.1, RV3.1, RV4.1, RV5.1, RV6.1
Changed lines of the file:
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@@
+    (pin "1")
+  )
+  (symbol (lib_id "power:+10V") (at 259.08 128.27 0) (unit 1)
+    (in_bom yes) (on_board yes) (fields_autoplaced)
+    (property "Reference" "#PWR?" (id 0) (at 259.08 132.08 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Value" "+10V" (id 1) (at 259.08 123.19 0))
+    (property "Footprint" "" (id 2) (at 259.08 128.27 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "" (id 3) (at 259.08 128.27 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
     (pin "1")
   )
@@
     (pin "1")
     (pin "2")
-  )
-  (symbol (lib_id "power:+5V") (at 171.45 58.42 0) (unit 1)
-    (in_bom yes) (on_board yes)
-    (property "Reference" "#PWR060" (id 0) (at 171.45 62.23 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Value" "+5V" (id 1) (at 171.45 54.61 0))
-    (property "Footprint" "" (id 2) (at 171.45 58.42 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Datasheet" "" (id 3) (at 171.45 58.42 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (pin "1")
   )
   (symbol (lib_id "power:GND") (at 82.55 64.77 0) (unit 1)
@@
     (pin "1")
   )
-  (symbol (lib_id "power:+5V") (at 171.45 128.27 0) (unit 1)
-    (in_bom yes) (on_board yes)
-    (property "Reference" "#PWR084" (id 0) (at 171.45 132.08 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Value" "+5V" (id 1) (at 171.45 124.46 0))
-    (property "Footprint" "" (id 2) (at 171.45 128.27 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Datasheet" "" (id 3) (at 171.45 128.27 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (pin "1")
-  )
   (symbol (lib_id "Connector:Screw_Terminal_01x04") (at 31.75 121.92 0) (mirror y) (unit 1)
     (in_bom yes) (on_board yes)
@@
     (pin "1")
   )
+  (symbol (lib_id "power:+10V") (at 82.55 57.15 0) (unit 1)
+    (in_bom yes) (on_board yes) (fields_autoplaced)
+    (property "Reference" "#PWR?" (id 0) (at 82.55 60.96 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Value" "+10V" (id 1) (at 82.55 52.07 0))
+    (property "Footprint" "" (id 2) (at 82.55 57.15 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "" (id 3) (at 82.55 57.15 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "1")
+  )
   (symbol (lib_id "Device:R_US") (at 246.38 111.76 180) (unit 1)
     (in_bom yes) (on_board yes)
@@
     (pin "3")
   )
-  (symbol (lib_id "power:+5V") (at 259.08 58.42 0) (unit 1)
-    (in_bom yes) (on_board yes)
-    (property "Reference" "#PWR061" (id 0) (at 259.08 62.23 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Value" "+5V" (id 1) (at 259.08 54.61 0))
-    (property "Footprint" "" (id 2) (at 259.08 58.42 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Datasheet" "" (id 3) (at 259.08 58.42 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (pin "1")
-  )
   (symbol (lib_id "power:GND") (at 129.54 129.54 0) (unit 1)
     (in_bom yes) (on_board yes) (fields_autoplaced)
@@
     )
     (property "Datasheet" "" (id 3) (at 171.45 66.04 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "1")
+  )
+  (symbol (lib_id "power:+10V") (at 171.45 58.42 0) (unit 1)
+    (in_bom yes) (on_board yes) (fields_autoplaced)
+    (property "Reference" "#PWR?" (id 0) (at 171.45 62.23 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Value" "+10V" (id 1) (at 171.45 53.34 0))
+    (property "Footprint" "" (id 2) (at 171.45 58.42 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "" (id 3) (at 171.45 58.42 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "1")
+  )
+  (symbol (lib_id "power:+10V") (at 171.45 128.27 0) (unit 1)
+    (in_bom yes) (on_board yes) (fields_autoplaced)
+    (property "Reference" "#PWR?" (id 0) (at 171.45 132.08 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Value" "+10V" (id 1) (at 171.45 123.19 0))
+    (property "Footprint" "" (id 2) (at 171.45 128.27 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "" (id 3) (at 171.45 128.27 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
     (pin "2")
   )
+  (symbol (lib_id "power:+10V") (at 259.08 58.42 0) (unit 1)
+    (in_bom yes) (on_board yes) (fields_autoplaced)
+    (property "Reference" "#PWR?" (id 0) (at 259.08 62.23 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Value" "+10V" (id 1) (at 259.08 53.34 0))
+    (property "Footprint" "" (id 2) (at 259.08 58.42 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "" (id 3) (at 259.08 58.42 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "1")
+  )
   (symbol (lib_id "Device:R_US") (at 71.12 121.92 180) (unit 1)
     (in_bom yes) (on_board yes) (fields_autoplaced)
@@
     (pin "3")
     (pin "4")
-  )
-  (symbol (lib_id "power:+5V") (at 82.55 57.15 0) (unit 1)
-    (in_bom yes) (on_board yes)
-    (property "Reference" "#PWR059" (id 0) (at 82.55 60.96 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Value" "+5V" (id 1) (at 82.55 53.34 0))
-    (property "Footprint" "" (id 2) (at 82.55 57.15 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Datasheet" "" (id 3) (at 82.55 57.15 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (pin "1")
   )
   (symbol (lib_id "Connector_Generic:Conn_02x06_Odd_Even") (at 97.79 168.91 0) (unit 1)
@@
     (pin "2")
   )
-  (symbol (lib_id "power:+5V") (at 259.08 128.27 0) (unit 1)
-    (in_bom yes) (on_board yes)
-    (property "Reference" "#PWR085" (id 0) (at 259.08 132.08 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Value" "+5V" (id 1) (at 259.08 124.46 0))
-    (property "Footprint" "" (id 2) (at 259.08 128.27 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Datasheet" "" (id 3) (at 259.08 128.27 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (pin "1")
-  )
   (symbol (lib_id "power:GND") (at 41.91 129.54 0) (unit 1)
     (in_bom yes) (on_board yes) (fields_autoplaced)
@@
     (pin "2")
   )
-  (symbol (lib_id "power:+5V") (at 83.82 128.27 0) (unit 1)
-    (in_bom yes) (on_board yes)
-    (property "Reference" "#PWR083" (id 0) (at 83.82 132.08 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Value" "+5V" (id 1) (at 83.82 124.46 0))
-    (property "Footprint" "" (id 2) (at 83.82 128.27 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Datasheet" "" (id 3) (at 83.82 128.27 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (pin "1")
-  )
   (symbol (lib_id "Device:R_Potentiometer") (at 259.08 62.23 0) (mirror y) (unit 1)
     (in_bom yes) (on_board yes) (fields_autoplaced)
@@
     (pin "2")
   )
+  (symbol (lib_id "power:+10V") (at 83.82 128.27 0) (unit 1)
+    (in_bom yes) (on_board yes) (fields_autoplaced)
+    (property "Reference" "#PWR?" (id 0) (at 83.82 132.08 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Value" "+10V" (id 1) (at 83.82 123.19 0))
+    (property "Footprint" "" (id 2) (at 83.82 128.27 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "" (id 3) (at 83.82 128.27 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "1")
+  )
   (symbol (lib_id "power:+5V") (at 64.77 114.3 0) (unit 1)
