File: lc_inamps.kicad_sch (KiCad schematic)
At the start: 44 parts, among them J13 Screw_Terminal_01x04, J14 Screw_Terminal_01x04, J15 Screw_Terminal_01x04, J16 Screw_Terminal_01x04, J17 Screw_Terminal_01x04, J18 Screw_Terminal_01x04, J19 Conn_01x06_Female, J20 Conn_02x06_Odd_Even, U3 MCP6N11T-001E, U4 MCP6N11T-001E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

Commit message: shuffle around some parts
Parts:
- F10, F11, F12, F7, F8, F9: value 3588-20 -> 178.6165; footprint 3588-20:358820 -> 178.6165:17861650002
- RV1, RV2, RV3, RV4, RV5, RV6: footprint 3296W-1-303LF:TRIM_3296W-1-303LF -> Potentiometer_THT:Potentiometer_Bourns_3296W_Vertical
Changed lines of the file:
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@@
       (effects (font (size 1.27 1.27)) (justify right))
     )
-    (property "Footprint" "3296W-1-303LF:TRIM_3296W-1-303LF" (id 2) (at 83.82 132.08 0)
+    (property "Footprint" "Potentiometer_THT:Potentiometer_Bourns_3296W_Vertical" (id 2) (at 83.82 132.08 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) (justify right))
     )
-    (property "Footprint" "3296W-1-303LF:TRIM_3296W-1-303LF" (id 2) (at 171.45 62.23 0)
+    (property "Footprint" "Potentiometer_THT:Potentiometer_Bourns_3296W_Vertical" (id 2) (at 171.45 62.23 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Value" "3588-20" (id 1) (at 203.2 113.03 0)
-      (effects (font (size 1.27 1.27)) (justify left))
-    )
-    (property "Footprint" "3588-20:358820" (id 2) (at 211.582 114.3 90)
+    (property "Value" "178.6165" (id 1) (at 203.2 113.03 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Footprint" "178.6165:17861650002" (id 2) (at 211.582 114.3 90)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) (justify right))
     )
-    (property "Footprint" "3296W-1-303LF:TRIM_3296W-1-303LF" (id 2) (at 259.08 132.08 0)
+    (property "Footprint" "Potentiometer_THT:Potentiometer_Bourns_3296W_Vertical" (id 2) (at 259.08 132.08 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) (justify right))
     )
-    (property "Footprint" "3296W-1-303LF:TRIM_3296W-1-303LF" (id 2) (at 82.55 60.96 0)
+    (property "Footprint" "Potentiometer_THT:Potentiometer_Bourns_3296W_Vertical" (id 2) (at 82.55 60.96 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Value" "3588-20" (id 1) (at 26.67 44.45 0)
-      (effects (font (size 1.27 1.27)) (justify left))
-    )
-    (property "Footprint" "3588-20:358820" (id 2) (at 35.052 44.45 90)
+    (property "Value" "178.6165" (id 1) (at 26.67 44.45 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Footprint" "178.6165:17861650002" (id 2) (at 35.052 44.45 90)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) (justify right))
     )
-    (property "Footprint" "3296W-1-303LF:TRIM_3296W-1-303LF" (id 2) (at 171.45 132.08 0)
+    (property "Footprint" "Potentiometer_THT:Potentiometer_Bourns_3296W_Vertical" (id 2) (at 171.45 132.08 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Value" "3588-20" (id 1) (at 201.93 43.18 0)
-      (effects (font (size 1.27 1.27)) (justify left))
-    )
-    (property "Footprint" "3588-20:358820" (id 2) (at 210.312 44.45 90)
+    (property "Value" "178.6165" (id 1) (at 201.93 43.18 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Footprint" "178.6165:17861650002" (id 2) (at 210.312 44.45 90)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Value" "3588-20" (id 1) (at 115.57 113.03 0)
-      (effects (font (size 1.27 1.27)) (justify left))
-    )
-    (property "Footprint" "3588-20:358820" (id 2) (at 123.952 114.3 90)
+    (property "Value" "178.6165" (id 1) (at 115.57 113.03 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Footprint" "178.6165:17861650002" (id 2) (at 123.952 114.3 90)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Value" "3588-20" (id 1) (at 114.3 43.18 0)
-      (effects (font (size 1.27 1.27)) (justify left))
-    )
-    (property "Footprint" "3588-20:358820" (id 2) (at 122.682 44.45 90)
+    (property "Value" "178.6165" (id 1) (at 114.3 43.18 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Footprint" "178.6165:17861650002" (id 2) (at 122.682 44.45 90)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Value" "3588-20" (id 1) (at 27.94 113.03 0)
-      (effects (font (size 1.27 1.27)) (justify left))
-    )
-    (property "Footprint" "3588-20:358820" (id 2) (at 36.322 114.3 90)
+    (property "Value" "178.6165" (id 1) (at 27.94 113.03 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Footprint" "178.6165:17861650002" (id 2) (at 36.322 114.3 90)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) (justify right))
     )
-    (property "Footprint" "3296W-1-303LF:TRIM_3296W-1-303LF" (id 2) (at 259.08 62.23 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
+    (property "Footprint" "Potentiometer_THT:Potentiometer_Bourns_3296W_Vertical" (id 2) (at 259.08 62.23 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )

Commit message: positioning for LC connectors
Parts:
- U3, U4, U5, U6, U7, U8: value MCP6N11T-001E -> MCP6N11; footprint Package_DFN_QFN:TDFN-8-1EP_3x2mm_P0.5mm_EP1.80x1.65mm -> Package_SO:SOIC-8_3.9x4.9mm_P1.27mm
- renumbered J13 to CON_LC1, J14 to CON_LC2, J15 to CON_LC3, J16 to CON_LC4, J17 to CON_LC5, J18 to CON_LC6
Connections:
- net GND: no longer U3.9 (PAD), U4.9 (PAD), U5.9 (PAD), U6.9 (PAD), U7.9 (PAD), U8.9 (PAD)
Other:
- moved on the sheet: CON_LC1, CON_LC2, CON_LC3, CON_LC4, CON_LC5, CON_LC6, F10, F11, F12, F7, F8, F9
