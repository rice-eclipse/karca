File: drivers.kicad_sch (KiCad schematic)
At the start: 61 parts, among them J10 Screw_Terminal_01x02, J11 Screw_Terminal_01x02, J12 Conn_01x08_Female, J6 Screw_Terminal_01x02, J7 Screw_Terminal_01x02, J8 Screw_Terminal_01x02, J9 Screw_Terminal_01x02, Q1 FQP30N06, Q2 FQP30N06, Q3 FQP30N06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

Commit message: some minor schematic cleanup
Parts:
- J12: value Conn_01x08_Female -> Conn_01x06_Female; footprint Connector_PinSocket_2.54mm:PinSocket_1x08_P2.54mm_Vertical -> Connector_PinSocket_2.54mm:PinSocket_1x06_P2.54mm_Vertical; symbol Connector:Conn_01x08_Female -> Connector:Conn_01x06_Female
- Q1, Q2, Q3, Q4, Q5, Q6: footprint Package_TO_SOT_THT:TO-220-3_Horizontal_TabDown -> Package_TO_SOT_THT:TO-220-3_Vertical
Connections:
- removed net drv_nc7: J12.7 (Pin_7)
- removed net drv_nc8: J12.8 (Pin_8)
- no-connect marks 2 -> 0

Commit message: shuffle around some parts
Parts:
- DRV_STAT_1: renamed from D7; value DRV_STAT_1 -> YLW
- DRV_STAT_2: renamed from D9; value DRV_STAT_2 -> YLW
- DRV_STAT_3: renamed from D10; value DRV_STAT_3 -> YLW
- DRV_STAT_4: renamed from D19; value DRV_STAT_4 -> YLW
- DRV_STAT_5: renamed from D16; value DRV_STAT_5 -> YLW
- DRV_STAT_6: renamed from D18; value DRV_STAT_6 -> YLW
- F1, F2, F3: value 3588-20 -> 178.6165; footprint 3588-20:358820 -> 178.6165:17861650002
- F4: renamed from F6; value 3588-20 -> 178.6165; footprint 3588-20:358820 -> 178.6165:17861650002
- F5: renamed from F4; value 3588-20 -> 178.6165; footprint 3588-20:358820 -> 178.6165:17861650002
- F6: renamed from F5; value 3588-20 -> 178.6165; footprint 3588-20:358820 -> 178.6165:17861650002
- FS_STAT_1: renamed from D8; value FS_STAT_1 -> BLU
- FS_STAT_2: renamed from D11; value FS_STAT_2 -> BLU
- FS_STAT_3: renamed from D12; value FS_STAT_3 -> BLU
- FS_STAT_4: renamed from D21; value FS_STAT_4 -> BLU
- FS_STAT_5: renamed from D17; value FS_STAT_5 -> BLU
- FS_STAT_6: renamed from D20; value FS_STAT_6 -> BLU
- renumbered J9 to J10, J10 to J11, J11 to J9, Q6 to Q4, Q4 to Q5, Q5 to Q6
Other:
- moved on the sheet: D24

Commit message: laid out ignition and PTs
Parts:
- D13, D14, D15, D22, D23, D24: value SS54 -> DO-214AC
- renumbered J6 to CON_DRV1, J7 to CON_DRV2, J8 to CON_DRV3, J9 to CON_DRV4, J10 to CON_DRV5, J11 to CON_DRV6
Changed lines of the file:
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@@
   (symbol (lib_id "Connector:Screw_Terminal_01x02") (at 219.71 105.41 0) (mirror y) (unit 1)
     (in_bom yes) (on_board yes)
-    (property "Reference" "J11" (id 0) (at 217.17 106.6799 0)
+    (property "Reference" "CON_DRV6" (id 0) (at 217.17 106.6799 0)
       (effects (font (size 1.27 1.27)) (justify left))
     )
@@
   (symbol (lib_id "Connector:Screw_Terminal_01x02") (at 132.08 34.29 0) (mirror y) (unit 1)
     (in_bom yes) (on_board yes)
-    (property "Reference" "J7" (id 0) (at 129.54 35.5599 0)
+    (property "Reference" "CON_DRV2" (id 0) (at 129.54 35.5599 0)
       (effects (font (size 1.27 1.27)) (justify left))
     )
@@
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Value" "SS54" (id 1) (at 163.83 113.0299 90)
+    (property "Value" "DO-214AC" (id 1) (at 163.83 113.0299 90)
       (effects (font (size 1.27 1.27)) (justify left))
     )
@@
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Value" "SS54" (id 1) (at 254 43.1799 90)
+    (property "Value" "DO-214AC" (id 1) (at 254 43.1799 90)
       (effects (font (size 1.27 1.27)) (justify left))
     )
@@
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Value" "SS54" (id 1) (at 254 114.2999 90)
+    (property "Value" "DO-214AC" (id 1) (at 254 114.2999 90)
       (effects (font (size 1.27 1.27)) (justify left))
     )
@@
   (symbol (lib_id "Connector:Screw_Terminal_01x02") (at 219.71 34.29 0) (mirror y) (unit 1)
     (in_bom yes) (on_board yes)
-    (property "Reference" "J8" (id 0) (at 217.17 35.5599 0)
+    (property "Reference" "CON_DRV3" (id 0) (at 217.17 35.5599 0)
       (effects (font (size 1.27 1.27)) (justify left))
     )
@@
   (symbol (lib_id "Connector:Screw_Terminal_01x02") (at 35.56 33.02 0) (mirror y) (unit 1)
     (in_bom yes) (on_board yes)
-    (property "Reference" "J6" (id 0) (at 33.02 34.2899 0)
+    (property "Reference" "CON_DRV1" (id 0) (at 33.02 34.2899 0)
       (effects (font (size 1.27 1.27)) (justify left))
     )
@@
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Value" "SS54" (id 1) (at 69.215 115.5699 90)
+    (property "Value" "DO-214AC" (id 1) (at 69.215 115.5699 90)
       (effects (font (size 1.27 1.27)) (justify left))
     )
@@
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Value" "SS54" (id 1) (at 68.58 41.9099 90)
+    (property "Value" "DO-214AC" (id 1) (at 68.58 41.9099 90)
       (effects (font (size 1.27 1.27)) (justify left))
     )
@@
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Value" "SS54" (id 1) (at 166.37 43.1799 90)
+    (property "Value" "DO-214AC" (id 1) (at 166.37 43.1799 90)
       (effects (font (size 1.27 1.27)) (justify left))
     )
@@
   (symbol (lib_id "Connector:Screw_Terminal_01x02") (at 132.08 104.14 0) (mirror y) (unit 1)
     (in_bom yes) (on_board yes)
-    (property "Reference" "J10" (id 0) (at 129.54 105.4099 0)
+    (property "Reference" "CON_DRV5" (id 0) (at 129.54 105.4099 0)
       (effects (font (size 1.27 1.27)) (justify left))
     )
@@
   (symbol (lib_id "Connector:Screw_Terminal_01x02") (at 36.83 106.68 0) (mirror y) (unit 1)
     (in_bom yes) (on_board yes)
-    (property "Reference" "J9" (id 0) (at 34.29 107.9499 0)
-      (effects (font (size 1.27 1.27)) (justify left))
-    )
+    (property "Reference" "CON_DRV4" (id 0) (at 34.29 107.9499 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )

Commit message: mostly finished routing
Connections:
- net +5V is gone; now on net +12V: R12.1, R13.1, R14.1, R24.1, R25.1, R26.1
Changed lines of the file:
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@@
     (pin "3")
-  )
-  (symbol (lib_id "power:+5V") (at 34.29 54.61 0) (unit 1)
-    (in_bom yes) (on_board yes) (fields_autoplaced)
-    (property "Reference" "#PWR020" (id 0) (at 34.29 58.42 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Value" "+5V" (id 1) (at 34.29 49.53 0))
-    (property "Footprint" "" (id 2) (at 34.29 54.61 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Datasheet" "" (id 3) (at 34.29 54.61 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (pin "1")
   )
   (symbol (lib_id "power:GND") (at 35.56 143.51 0) (unit 1)
@@
     )
     (property "Datasheet" "" (id 3) (at 171.45 55.88 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "1")
+  )
+  (symbol (lib_name "+12V_1") (lib_id "power:+12V") (at 34.29 54.61 0) (unit 1)
+    (in_bom yes) (on_board yes) (fields_autoplaced)
+    (property "Reference" "#PWR0170" (id 0) (at 34.29 58.42 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Value" "+12V" (id 1) (at 34.29 49.53 0))
+    (property "Footprint" "" (id 2) (at 34.29 54.61 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "" (id 3) (at 34.29 54.61 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
     (pin "1")
   )
+  (symbol (lib_name "+12V_1") (lib_id "power:+12V") (at 130.81 125.73 0) (unit 1)
+    (in_bom yes) (on_board yes) (fields_autoplaced)
+    (property "Reference" "#PWR0168" (id 0) (at 130.81 129.54 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Value" "+12V" (id 1) (at 130.81 120.65 0))
+    (property "Footprint" "" (id 2) (at 130.81 125.73 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "" (id 3) (at 130.81 125.73 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "1")
+  )
   (symbol (lib_id "Device:Q_NMOS_GDS") (at 45.72 62.23 0) (unit 1)
     (in_bom yes) (on_board yes) (fields_autoplaced)
@@
     (pin "1")
     (pin "2")
-  )
-  (symbol (lib_id "power:+5V") (at 130.81 125.73 0) (unit 1)
-    (in_bom yes) (on_board yes) (fields_autoplaced)
-    (property "Reference" "#PWR035" (id 0) (at 130.81 129.54 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Value" "+5V" (id 1) (at 130.81 120.65 0))
-    (property "Footprint" "" (id 2) (at 130.81 125.73 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Datasheet" "" (id 3) (at 130.81 125.73 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (pin "1")
-  )
-  (symbol (lib_id "power:+5V") (at 218.44 55.88 0) (unit 1)
-    (in_bom yes) (on_board yes) (fields_autoplaced)
-    (property "Reference" "#PWR024" (id 0) (at 218.44 59.69 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Value" "+5V" (id 1) (at 218.44 50.8 0))
-    (property "Footprint" "" (id 2) (at 218.44 55.88 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Datasheet" "" (id 3) (at 218.44 55.88 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (pin "1")
   )
   (symbol (lib_id "power:GND") (at 171.45 125.73 0) (unit 1)
@@
     (pin "2")
   )
+  (symbol (lib_name "+12V_1") (lib_id "power:+12V") (at 35.56 128.27 0) (unit 1)
+    (in_bom yes) (on_board yes) (fields_autoplaced)
+    (property "Reference" "#PWR0172" (id 0) (at 35.56 132.08 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Value" "+12V" (id 1) (at 35.56 123.19 0))
+    (property "Footprint" "" (id 2) (at 35.56 128.27 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "" (id 3) (at 35.56 128.27 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "1")
+  )
   (symbol (lib_id "Device:R_US") (at 34.29 58.42 0) (unit 1)
     (in_bom yes) (on_board yes) (fields_autoplaced)
@@
     (pin "3")
   )
-  (symbol (lib_id "power:+5V") (at 130.81 55.88 0) (unit 1)
-    (in_bom yes) (on_board yes) (fields_autoplaced)
-    (property "Reference" "#PWR022" (id 0) (at 130.81 59.69 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Value" "+5V" (id 1) (at 130.81 50.8 0))
-    (property "Footprint" "" (id 2) (at 130.81 55.88 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Datasheet" "" (id 3) (at 130.81 55.88 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (pin "1")
-  )
   (symbol (lib_id "Device:Fuse") (at 144.78 29.21 0) (unit 1)
     (in_bom yes) (on_board yes) (fields_autoplaced)
@@
     (pin "2")
   )
-  (symbol (lib_id "power:+5V") (at 218.44 127 0) (unit 1)
-    (in_bom yes) (on_board yes) (fields_autoplaced)
-    (property "Reference" "#PWR037" (id 0) (at 218.44 130.81 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Value" "+5V" (id 1) (at 218.44 121.92 0))
-    (property "Footprint" "" (id 2) (at 218.44 127 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Datasheet" "" (id 3) (at 218.44 127 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (pin "1")
-  )
   (symbol (lib_id "power:GND") (at 232.41 68.58 0) (unit 1)
     (in_bom yes) (on_board yes) (fields_autoplaced)
@@
     )
     (property "Datasheet" "" (id 3) (at 232.41 68.58 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (pin "1")
-  )
-  (symbol (lib_id "power:+5V") (at 35.56 128.27 0) (unit 1)
-    (in_bom yes) (on_board yes) (fields_autoplaced)
-    (property "Reference" "#PWR039" (id 0) (at 35.56 132.08 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Value" "+5V" (id 1) (at 35.56 123.19 0))
-    (property "Footprint" "" (id 2) (at 35.56 128.27 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Datasheet" "" (id 3) (at 35.56 128.27 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
     (pin "2")
   )
+  (symbol (lib_name "+12V_1") (lib_id "power:+12V") (at 218.44 127 0) (unit 1)
+    (in_bom yes) (on_board yes) (fields_autoplaced)
+    (property "Reference" "#PWR0169" (id 0) (at 218.44 130.81 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Value" "+12V" (id 1) (at 218.44 121.92 0))
+    (property "Footprint" "" (id 2) (at 218.44 127 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "" (id 3) (at 218.44 127 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "1")
+  )
   (symbol (lib_id "Device:LED") (at 49.53 110.49 90) (unit 1)
     (in_bom yes) (on_board yes)
@@
     (pin "1")
     (pin "2")
+  )
+  (symbol (lib_name "+12V_1") (lib_id "power:+12V") (at 218.44 55.88 0) (unit 1)
+    (in_bom yes) (on_board yes) (fields_autoplaced)
+    (property "Reference" "#PWR0171" (id 0) (at 218.44 59.69 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Value" "+12V" (id 1) (at 218.44 50.8 0))
+    (property "Footprint" "" (id 2) (at 218.44 55.88 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "" (id 3) (at 218.44 55.88 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "1")
   )
   (symbol (lib_id "Device:D") (at 66.675 114.3 270) (unit 1)
@@
     (pin "2")
   )
+  (symbol (lib_name "+12V_1") (lib_id "power:+12V") (at 130.81 55.88 0) (unit 1)
+    (in_bom yes) (on_board yes) (fields_autoplaced)
+    (property "Reference" "#PWR0173" (id 0) (at 130.81 59.69 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Value" "+12V" (id 1) (at 130.81 50.8 0))
+    (property "Footprint" "" (id 2) (at 130.81 55.88 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "" (id 3) (at 130.81 55.88 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "1")
+  )
   (symbol (lib_id "power:+12V") (at 232.41 25.4 0) (unit 1)
